* SPICE3 file created from cryoInst.ext - technology: sky130A

.subckt cryoInst EBL OUT
C0 sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1_114/Y 2.33fF
C1 sky130_fd_sc_hd__dfxtp_1_9/a_27_47# sky130_fd_sc_hd__dfxtp_1_9/a_193_47# 2.23fF
C2 sky130_fd_sc_hd__dfxtp_1_1/a_27_47# sky130_fd_sc_hd__dfxtp_1_1/a_193_47# 2.23fF
C3 sky130_fd_sc_hd__inv_1_130/Y OUT 2.44fF
C4 sky130_fd_sc_hd__dfxtp_1_8/a_27_47# sky130_fd_sc_hd__dfxtp_1_8/a_193_47# 2.23fF
C5 sky130_fd_sc_hd__dfxtp_1_7/a_27_47# sky130_fd_sc_hd__dfxtp_1_7/a_193_47# 2.23fF
C6 sky130_fd_sc_hd__dfxtp_1_3/a_193_47# sky130_fd_sc_hd__dfxtp_1_3/a_27_47# 2.23fF
C7 sky130_fd_sc_hd__inv_1_135/Y sky130_fd_sc_hd__inv_1_0/VPB 3.10fF
C8 sky130_fd_sc_hd__dfxtp_1_6/a_193_47# sky130_fd_sc_hd__dfxtp_1_6/a_27_47# 2.23fF
C9 sky130_fd_sc_hd__dfxtp_1_4/a_27_47# sky130_fd_sc_hd__dfxtp_1_4/a_193_47# 2.23fF
C10 sky130_fd_sc_hd__dfxtp_1_2/a_193_47# sky130_fd_sc_hd__dfxtp_1_2/a_27_47# 2.23fF
C11 sky130_fd_sc_hd__dfxtp_1_0/a_27_47# sky130_fd_sc_hd__dfxtp_1_0/a_193_47# 2.23fF
C12 sky130_fd_sc_hd__dfxtp_1_5/a_27_47# sky130_fd_sc_hd__dfxtp_1_5/a_193_47# 2.23fF
Xsky130_fd_sc_hd__fill_8_53 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_42 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_64 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_20 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_31 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__dfxtp_1_4 sky130_fd_sc_hd__inv_1_113/A sky130_fd_sc_hd__inv_1_137/A
+ sky130_fd_sc_hd__inv_1_113/Y sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__dfxtp_1
Xsky130_fd_sc_hd__fill_1_139 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_106 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_128 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_117 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_4 sky130_fd_sc_hd__inv_1_4/Y sky130_fd_sc_hd__inv_1_4/A VSUBS
+ sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_59 sky130_fd_sc_hd__inv_1_59/Y sky130_fd_sc_hd__inv_1_88/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_26 sky130_fd_sc_hd__inv_1_31/A sky130_fd_sc_hd__inv_1_27/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_15 sky130_fd_sc_hd__inv_1_15/Y sky130_fd_sc_hd__inv_1_16/A
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_37 sky130_fd_sc_hd__inv_1_41/A sky130_fd_sc_hd__inv_1_37/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_48 sky130_fd_sc_hd__inv_1_49/A sky130_fd_sc_hd__inv_1_48/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_88 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_77 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_99 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_66 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_22 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_55 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_11 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_44 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_33 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_1 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_8_43 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_54 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_32 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_65 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_21 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_10 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__dfxtp_1_5 sky130_fd_sc_hd__inv_1_115/A sky130_fd_sc_hd__inv_1_134/A
+ sky130_fd_sc_hd__inv_1_115/Y sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__dfxtp_1
Xsky130_fd_sc_hd__fill_1_107 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_129 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_118 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_5 sky130_fd_sc_hd__inv_1_5/Y sky130_fd_sc_hd__inv_1_6/Y VSUBS
+ sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_27 sky130_fd_sc_hd__inv_1_27/Y sky130_fd_sc_hd__inv_1_28/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_16 sky130_fd_sc_hd__inv_1_16/Y sky130_fd_sc_hd__inv_1_16/A
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_38 sky130_fd_sc_hd__inv_1_39/A sky130_fd_sc_hd__inv_1_41/Y
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_49 sky130_fd_sc_hd__inv_1_50/A sky130_fd_sc_hd__inv_1_49/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_89 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_78 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_67 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_12 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_23 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_56 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_45 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_34 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_2 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_8_33 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_44 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_55 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_66 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_22 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_11 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__dfxtp_1_6 OUT sky130_fd_sc_hd__inv_1_135/A sky130_fd_sc_hd__inv_1_130/Y
+ sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__dfxtp_1
Xsky130_fd_sc_hd__fill_1_108 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_119 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_6 sky130_fd_sc_hd__inv_1_6/Y sky130_fd_sc_hd__inv_1_7/Y VSUBS
+ sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_28 sky130_fd_sc_hd__inv_1_28/Y sky130_fd_sc_hd__inv_1_29/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_17 sky130_fd_sc_hd__inv_1_17/Y sky130_fd_sc_hd__inv_1_18/Y
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_39 sky130_fd_sc_hd__inv_1_42/A sky130_fd_sc_hd__inv_1_39/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_79 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_68 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_24 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_13 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_57 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_46 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_35 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_3 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_8_34 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_56 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_45 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_67 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_23 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_12 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__inv_1_150 sky130_fd_sc_hd__inv_1_93/A sky130_fd_sc_hd__inv_1_150/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__dfxtp_1_7 sky130_fd_sc_hd__inv_1_114/A sky130_fd_sc_hd__inv_1_131/A
+ sky130_fd_sc_hd__inv_1_114/Y sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__dfxtp_1
Xsky130_fd_sc_hd__fill_1_109 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_7 sky130_fd_sc_hd__inv_1_7/Y sky130_fd_sc_hd__inv_1_8/Y VSUBS
+ sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_29 sky130_fd_sc_hd__inv_1_29/Y sky130_fd_sc_hd__inv_1_30/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_18 sky130_fd_sc_hd__inv_1_18/Y sky130_fd_sc_hd__inv_1_19/Y
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_69 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_25 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_14 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_58 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_47 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_36 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_4 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_8_46 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_35 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_57 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_68 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_13 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_24 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__inv_1_151 sky130_fd_sc_hd__inv_1_151/Y sky130_fd_sc_hd__inv_1_151/A
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_140 sky130_fd_sc_hd__inv_1_140/Y sky130_fd_sc_hd__inv_1_149/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__dfxtp_1_8 sky130_fd_sc_hd__inv_1_134/A sky130_fd_sc_hd__inv_1_112/A
+ sky130_fd_sc_hd__inv_1_134/Y sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__dfxtp_1
Xsky130_fd_sc_hd__inv_1_8 sky130_fd_sc_hd__inv_1_8/Y sky130_fd_sc_hd__inv_1_9/Y VSUBS
+ sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_19 sky130_fd_sc_hd__inv_1_19/Y sky130_fd_sc_hd__inv_1_20/Y
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_37 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_15 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_26 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_59 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_48 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_5 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_8_47 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_58 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_36 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_25 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_14 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__inv_1_130 sky130_fd_sc_hd__inv_1_130/Y OUT VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_141 sky130_fd_sc_hd__inv_1_149/A sky130_fd_sc_hd__inv_1_144/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_152 sky130_fd_sc_hd__inv_1_152/Y sky130_fd_sc_hd__inv_1_3/Y
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__dfxtp_1_9 sky130_fd_sc_hd__inv_1_112/A sky130_fd_sc_hd__inv_1_16/Y
+ sky130_fd_sc_hd__inv_1_112/Y sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__dfxtp_1
Xsky130_fd_sc_hd__inv_1_9 sky130_fd_sc_hd__inv_1_9/Y sky130_fd_sc_hd__inv_1_9/A VSUBS
+ sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_38 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_16 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_27 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_49 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_6 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_8_37 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_48 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_59 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_15 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_26 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__inv_1_153 sky130_fd_sc_hd__inv_1_153/Y sky130_fd_sc_hd__inv_1_153/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_131 sky130_fd_sc_hd__inv_1_131/Y sky130_fd_sc_hd__inv_1_131/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_120 sky130_fd_sc_hd__inv_1_121/A sky130_fd_sc_hd__inv_1_123/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_142 sky130_fd_sc_hd__inv_1_145/A sky130_fd_sc_hd__inv_1_151/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_17 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_28 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_8_0 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_2_39 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_7 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_8_38 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_49 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_16 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_27 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__inv_1_132 sky130_fd_sc_hd__inv_1_150/A sky130_fd_sc_hd__inv_1_83/Y
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_110 sky130_fd_sc_hd__inv_1_111/A sky130_fd_sc_hd__inv_1_110/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_121 sky130_fd_sc_hd__inv_1_122/A sky130_fd_sc_hd__inv_1_121/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_154 sky130_fd_sc_hd__inv_1_154/Y sky130_fd_sc_hd__inv_1_31/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_143 sky130_fd_sc_hd__inv_1_10/A sky130_fd_sc_hd__inv_1_143/A
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__decap_4_20 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_2_18 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_29 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_8_1 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_1_8 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_8_39 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_17 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_28 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__inv_1_100 sky130_fd_sc_hd__inv_1_96/A sky130_fd_sc_hd__inv_1_94/Y
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_111 sky130_fd_sc_hd__inv_1_111/Y sky130_fd_sc_hd__inv_1_111/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_133 sky130_fd_sc_hd__inv_1_151/A sky130_fd_sc_hd__inv_1_60/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_122 sky130_fd_sc_hd__inv_1_126/A sky130_fd_sc_hd__inv_1_122/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_144 sky130_fd_sc_hd__inv_1_144/Y sky130_fd_sc_hd__inv_1_146/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__decap_4_10 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__decap_4_21 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__tapvpwrvgnd_1_0 sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_8_2 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_2_19 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_9 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_8_18 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_29 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__inv_1_101 sky130_fd_sc_hd__inv_1_153/A sky130_fd_sc_hd__inv_1_111/Y
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_112 sky130_fd_sc_hd__inv_1_112/Y sky130_fd_sc_hd__inv_1_112/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_123 sky130_fd_sc_hd__inv_1_123/Y sky130_fd_sc_hd__inv_1_154/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_134 sky130_fd_sc_hd__inv_1_134/Y sky130_fd_sc_hd__inv_1_134/A
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_145 sky130_fd_sc_hd__inv_1_148/A sky130_fd_sc_hd__inv_1_145/A
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_30 sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__decap_4_11 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__decap_4_22 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__tapvpwrvgnd_1_1 sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_8_3 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_19 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__inv_1_102 sky130_fd_sc_hd__inv_1_107/A sky130_fd_sc_hd__inv_1_103/Y
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_113 sky130_fd_sc_hd__inv_1_113/Y sky130_fd_sc_hd__inv_1_113/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_124 sky130_fd_sc_hd__inv_1_124/Y sky130_fd_sc_hd__inv_1_129/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_135 sky130_fd_sc_hd__inv_1_135/Y sky130_fd_sc_hd__inv_1_135/A
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_146 sky130_fd_sc_hd__inv_1_146/Y sky130_fd_sc_hd__inv_1_147/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_20 sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_31 sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__decap_4_12 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__decap_4_23 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__tapvpwrvgnd_1_2 sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_8_4 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__inv_1_103 sky130_fd_sc_hd__inv_1_103/Y sky130_fd_sc_hd__inv_1_104/Y
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_114 sky130_fd_sc_hd__inv_1_114/Y sky130_fd_sc_hd__inv_1_114/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_147 sky130_fd_sc_hd__inv_1_147/Y sky130_fd_sc_hd__inv_1_148/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_125 sky130_fd_sc_hd__inv_1_33/A sky130_fd_sc_hd__inv_1_152/Y
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_136 sky130_fd_sc_hd__inv_1_143/A sky130_fd_sc_hd__inv_1_44/Y
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_21 sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_32 sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_10 sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__decap_4_13 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__tapvpwrvgnd_1_3 sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_8_5 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__inv_1_115 sky130_fd_sc_hd__inv_1_115/Y sky130_fd_sc_hd__inv_1_115/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_104 sky130_fd_sc_hd__inv_1_104/Y sky130_fd_sc_hd__inv_1_105/Y
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_126 sky130_fd_sc_hd__inv_1_127/A sky130_fd_sc_hd__inv_1_126/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_137 sky130_fd_sc_hd__inv_1_137/Y sky130_fd_sc_hd__inv_1_137/A
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_148 sky130_fd_sc_hd__inv_1_148/Y sky130_fd_sc_hd__inv_1_148/A
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_22 sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_33 sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_11 sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__decap_4_14 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__tapvpwrvgnd_1_4 sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_8_6 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_4_0 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__inv_1_105 sky130_fd_sc_hd__inv_1_105/Y sky130_fd_sc_hd__inv_1_106/Y
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_127 sky130_fd_sc_hd__inv_1_128/A sky130_fd_sc_hd__inv_1_127/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_116 sky130_fd_sc_hd__inv_1_117/A sky130_fd_sc_hd__inv_1_124/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_149 sky130_fd_sc_hd__inv_1_149/Y sky130_fd_sc_hd__inv_1_149/A
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_138 sky130_fd_sc_hd__inv_1_52/A sky130_fd_sc_hd__inv_1_139/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_23 sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_34 sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_12 sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__decap_4_15 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_2_160 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__tapvpwrvgnd_1_5 sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_8_7 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_4_1 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__inv_1_106 sky130_fd_sc_hd__inv_1_106/Y sky130_fd_sc_hd__inv_1_118/Y
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_128 sky130_fd_sc_hd__inv_1_129/A sky130_fd_sc_hd__inv_1_128/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_117 sky130_fd_sc_hd__inv_1_118/A sky130_fd_sc_hd__inv_1_117/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_139 sky130_fd_sc_hd__inv_1_139/Y sky130_fd_sc_hd__inv_1_140/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_24 sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_13 sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__decap_4_16 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_2_161 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_150 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__tapvpwrvgnd_1_6 sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_8_8 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_4_2 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__inv_1_107 sky130_fd_sc_hd__inv_1_109/A sky130_fd_sc_hd__inv_1_107/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_129 sky130_fd_sc_hd__inv_1_129/Y sky130_fd_sc_hd__inv_1_129/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_118 sky130_fd_sc_hd__inv_1_118/Y sky130_fd_sc_hd__inv_1_118/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_25 sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_14 sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__decap_4_17 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_1_90 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_2_151 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_162 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_140 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__tapvpwrvgnd_1_7 sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_8_9 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_4_3 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__inv_1_119 sky130_fd_sc_hd__inv_1_75/A sky130_fd_sc_hd__inv_1_153/Y
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_108 sky130_fd_sc_hd__inv_1_110/A sky130_fd_sc_hd__inv_1_109/Y
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_0 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__tapvpwrvgnd_1_26 sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_15 sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__decap_4_18 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_2_130 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_152 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_141 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__tapvpwrvgnd_1_8 sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_1_91 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_80 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_4_4 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__inv_1_109 sky130_fd_sc_hd__inv_1_109/Y sky130_fd_sc_hd__inv_1_109/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_1 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__tapvpwrvgnd_1_16 sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_27 sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__decap_4_19 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_2_131 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_153 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_120 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_142 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__tapvpwrvgnd_1_9 sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_1_92 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_81 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_70 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_4_5 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_2_2 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__tapvpwrvgnd_1_28 sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_17 sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_2_132 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_121 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_110 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_154 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_143 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_93 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_82 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_60 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_71 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_4_6 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_2_3 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__tapvpwrvgnd_1_18 sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__tapvpwrvgnd_1_29 sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_2_122 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_133 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_111 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_100 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_155 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_144 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_94 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_83 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_50 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_61 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_72 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_4_7 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__tapvpwrvgnd_1_19 sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__tapvpwrvgnd_1
Xsky130_fd_sc_hd__fill_2_4 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_134 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_95 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_2_123 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_112 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_101 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_156 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_84 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_2_145 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_51 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_40 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_62 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_73 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_4_8 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_2_5 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_113 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_124 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_102 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_157 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_135 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_146 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_96 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_85 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_52 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_41 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_30 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_63 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_74 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_4_9 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_2_6 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_125 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_114 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_103 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_158 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_136 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_147 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_97 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_180 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_86 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_53 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_20 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_31 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_64 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_75 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_42 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_4_20 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_2_7 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_104 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_126 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_115 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_159 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_148 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_137 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_98 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_170 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_181 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_87 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_21 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_32 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_10 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_54 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_65 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_76 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_43 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_90 sky130_fd_sc_hd__inv_1_91/A sky130_fd_sc_hd__inv_1_95/Y
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_4_21 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_4_10 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_2_8 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_105 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_127 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_116 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_149 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_138 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_99 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_171 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_88 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_182 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_160 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_22 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_33 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_55 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_11 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_77 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_66 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_44 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_80 sky130_fd_sc_hd__inv_1_80/Y sky130_fd_sc_hd__inv_1_80/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_91 sky130_fd_sc_hd__inv_1_92/A sky130_fd_sc_hd__inv_1_91/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__decap_4_0 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_4_22 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_4_11 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_2_9 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_128 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_117 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_106 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_78 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_89 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_2_139 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_23 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_34 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_12 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_56 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_67 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_45 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_150 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_183 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_172 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_161 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_81 sky130_fd_sc_hd__inv_1_82/A sky130_fd_sc_hd__inv_1_86/Y
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_70 sky130_fd_sc_hd__inv_1_71/A sky130_fd_sc_hd__inv_1_70/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_92 sky130_fd_sc_hd__inv_1_94/A sky130_fd_sc_hd__inv_1_92/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__decap_4_1 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_4_23 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_4_12 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_2_118 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_107 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_129 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_24 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_13 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_140 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_173 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_151 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_79 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_184 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_162 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_35 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_57 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_68 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_46 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_82 sky130_fd_sc_hd__inv_1_83/A sky130_fd_sc_hd__inv_1_82/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_71 sky130_fd_sc_hd__inv_1_72/A sky130_fd_sc_hd__inv_1_71/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_93 sky130_fd_sc_hd__inv_1_95/A sky130_fd_sc_hd__inv_1_93/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_60 sky130_fd_sc_hd__inv_1_60/Y sky130_fd_sc_hd__inv_1_61/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__decap_4_2 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_4_13 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_4_24 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_2_119 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_108 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__nand2_1_0 sky130_fd_sc_hd__inv_1_16/A sky130_fd_sc_hd__inv_1_17/Y
+ EBL VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__fill_1_141 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_130 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_152 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_174 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_185 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_163 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_47 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_25 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_36 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_14 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_58 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_69 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_50 sky130_fd_sc_hd__inv_1_51/A sky130_fd_sc_hd__inv_1_50/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_83 sky130_fd_sc_hd__inv_1_83/Y sky130_fd_sc_hd__inv_1_83/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_72 sky130_fd_sc_hd__inv_1_73/A sky130_fd_sc_hd__inv_1_72/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_94 sky130_fd_sc_hd__inv_1_94/Y sky130_fd_sc_hd__inv_1_94/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_61 sky130_fd_sc_hd__inv_1_61/Y sky130_fd_sc_hd__inv_1_62/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_90 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__decap_4_3 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_4_14 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_4_25 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_2_109 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_153 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_131 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_142 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_120 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_175 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_186 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_164 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_48 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_37 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_26 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_15 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_59 sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_84 sky130_fd_sc_hd__inv_1_85/A sky130_fd_sc_hd__inv_1_89/Y
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_73 sky130_fd_sc_hd__inv_1_74/A sky130_fd_sc_hd__inv_1_73/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_95 sky130_fd_sc_hd__inv_1_95/Y sky130_fd_sc_hd__inv_1_95/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_62 sky130_fd_sc_hd__inv_1_62/Y sky130_fd_sc_hd__inv_1_62/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_40 sky130_fd_sc_hd__inv_1_40/Y sky130_fd_sc_hd__inv_1_42/Y
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_51 sky130_fd_sc_hd__inv_1_53/A sky130_fd_sc_hd__inv_1_51/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_80 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_91 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__decap_4_4 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_4_15 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_4_26 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_1_110 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_154 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_132 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_143 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_121 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_176 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_165 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_49 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_27 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_38 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_16 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_85 sky130_fd_sc_hd__inv_1_86/A sky130_fd_sc_hd__inv_1_85/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_74 sky130_fd_sc_hd__inv_1_89/A sky130_fd_sc_hd__inv_1_74/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_96 sky130_fd_sc_hd__inv_1_97/A sky130_fd_sc_hd__inv_1_96/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_63 sky130_fd_sc_hd__inv_1_64/A sky130_fd_sc_hd__inv_1_66/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_30 sky130_fd_sc_hd__inv_1_30/Y sky130_fd_sc_hd__inv_1_56/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_41 sky130_fd_sc_hd__inv_1_41/Y sky130_fd_sc_hd__inv_1_41/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_52 sky130_fd_sc_hd__inv_1_52/Y sky130_fd_sc_hd__inv_1_52/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_92 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_81 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_70 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__decap_4_5 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_4_16 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_4_27 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_1_100 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_111 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_133 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_122 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_28 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_17 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_39 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_144 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_177 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_166 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_155 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_86 sky130_fd_sc_hd__inv_1_86/Y sky130_fd_sc_hd__inv_1_86/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_75 sky130_fd_sc_hd__inv_1_76/A sky130_fd_sc_hd__inv_1_75/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_97 sky130_fd_sc_hd__inv_1_98/A sky130_fd_sc_hd__inv_1_97/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_64 sky130_fd_sc_hd__inv_1_88/A sky130_fd_sc_hd__inv_1_64/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_31 sky130_fd_sc_hd__inv_1_31/Y sky130_fd_sc_hd__inv_1_31/A
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_20 sky130_fd_sc_hd__inv_1_20/Y sky130_fd_sc_hd__inv_1_54/Y
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_42 sky130_fd_sc_hd__inv_1_42/Y sky130_fd_sc_hd__inv_1_42/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_53 sky130_fd_sc_hd__inv_1_53/Y sky130_fd_sc_hd__inv_1_53/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_82 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_93 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_71 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_60 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__decap_4_6 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_4_17 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_4_28 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_1_18 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_29 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_101 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_112 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_134 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_145 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_123 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_178 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_167 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_156 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_76 sky130_fd_sc_hd__inv_1_80/A sky130_fd_sc_hd__inv_1_76/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_87 sky130_fd_sc_hd__inv_1_87/Y sky130_fd_sc_hd__inv_1_87/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_98 sky130_fd_sc_hd__inv_1_99/A sky130_fd_sc_hd__inv_1_98/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_65 sky130_fd_sc_hd__inv_1_66/A sky130_fd_sc_hd__inv_1_99/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_54 sky130_fd_sc_hd__inv_1_54/Y sky130_fd_sc_hd__inv_1_5/Y
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_21 sky130_fd_sc_hd__inv_1_55/A sky130_fd_sc_hd__inv_1_21/A
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_10 sky130_fd_sc_hd__inv_1_9/A sky130_fd_sc_hd__inv_1_10/A
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_32 sky130_fd_sc_hd__inv_1_34/A sky130_fd_sc_hd__inv_1_33/Y
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_43 sky130_fd_sc_hd__inv_1_44/A sky130_fd_sc_hd__inv_1_45/Y
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_94 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_83 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_72 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_50 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_61 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__decap_4_7 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_8_60 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_4_18 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__fill_4_29 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__dfxtp_1_0 sky130_fd_sc_hd__inv_1_135/A sky130_fd_sc_hd__inv_1_113/A
+ sky130_fd_sc_hd__inv_1_135/Y sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__dfxtp_1
Xsky130_fd_sc_hd__fill_1_102 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_146 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_113 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_135 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_124 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_179 sky130_fd_sc_hd__inv_1_88/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_168 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_157 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_0 sky130_fd_sc_hd__inv_1_0/Y sky130_fd_sc_hd__inv_1_0/A VSUBS
+ sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_1_19 sky130_fd_sc_hd__inv_1_9/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_66 sky130_fd_sc_hd__inv_1_66/Y sky130_fd_sc_hd__inv_1_66/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_11 sky130_fd_sc_hd__inv_1_2/A sky130_fd_sc_hd__inv_1_12/Y
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_55 sky130_fd_sc_hd__inv_1_4/A sky130_fd_sc_hd__inv_1_55/A
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_33 sky130_fd_sc_hd__inv_1_33/Y sky130_fd_sc_hd__inv_1_33/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_44 sky130_fd_sc_hd__inv_1_44/Y sky130_fd_sc_hd__inv_1_44/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_22 sky130_fd_sc_hd__inv_1_56/A sky130_fd_sc_hd__inv_1_23/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_77 sky130_fd_sc_hd__inv_1_78/A sky130_fd_sc_hd__inv_1_80/Y
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_99 sky130_fd_sc_hd__inv_1_99/Y sky130_fd_sc_hd__inv_1_99/A
+ VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_88 sky130_fd_sc_hd__inv_1_88/Y sky130_fd_sc_hd__inv_1_88/A
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_95 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_84 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_73 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_40 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_51 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_62 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__decap_4_8 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_8_50 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_61 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_4_19 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_4
Xsky130_fd_sc_hd__dfxtp_1_1 sky130_fd_sc_hd__inv_1_137/A sky130_fd_sc_hd__inv_1_114/A
+ sky130_fd_sc_hd__inv_1_137/Y sky130_fd_sc_hd__inv_1_53/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__dfxtp_1
Xsky130_fd_sc_hd__fill_1_114 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_103 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_147 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_136 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_125 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_158 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_169 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_1 sky130_fd_sc_hd__inv_1_1/Y sky130_fd_sc_hd__inv_1_4/Y VSUBS
+ sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_89 sky130_fd_sc_hd__inv_1_89/Y sky130_fd_sc_hd__inv_1_89/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_78 sky130_fd_sc_hd__inv_1_79/A sky130_fd_sc_hd__inv_1_78/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_67 sky130_fd_sc_hd__inv_1_68/A sky130_fd_sc_hd__inv_1_87/Y
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_12 sky130_fd_sc_hd__inv_1_12/Y sky130_fd_sc_hd__inv_1_1/Y
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_34 sky130_fd_sc_hd__inv_1_35/A sky130_fd_sc_hd__inv_1_34/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_45 sky130_fd_sc_hd__inv_1_45/Y sky130_fd_sc_hd__inv_1_53/Y
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_23 sky130_fd_sc_hd__inv_1_23/Y sky130_fd_sc_hd__inv_1_25/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_56 sky130_fd_sc_hd__inv_1_56/Y sky130_fd_sc_hd__inv_1_56/A
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_96 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_85 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_74 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_41 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_30 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_52 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_63 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__decap_4_9 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__decap_4
Xsky130_fd_sc_hd__fill_8_40 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_51 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_62 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__dfxtp_1_2 sky130_fd_sc_hd__inv_1_0/A sky130_fd_sc_hd__inv_1_115/A
+ sky130_fd_sc_hd__inv_1_0/Y sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__dfxtp_1
Xsky130_fd_sc_hd__fill_1_104 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_148 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_137 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_115 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_126 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_159 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_2 sky130_fd_sc_hd__inv_1_3/A sky130_fd_sc_hd__inv_1_2/A VSUBS
+ sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_79 sky130_fd_sc_hd__inv_1_87/A sky130_fd_sc_hd__inv_1_79/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_68 sky130_fd_sc_hd__inv_1_69/A sky130_fd_sc_hd__inv_1_68/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_57 sky130_fd_sc_hd__inv_1_62/A sky130_fd_sc_hd__inv_1_58/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_13 sky130_fd_sc_hd__inv_1_21/A sky130_fd_sc_hd__inv_1_14/Y
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_35 sky130_fd_sc_hd__inv_1_36/A sky130_fd_sc_hd__inv_1_35/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_46 sky130_fd_sc_hd__inv_1_47/A sky130_fd_sc_hd__inv_1_52/Y
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_24 sky130_fd_sc_hd__inv_1_25/A sky130_fd_sc_hd__inv_1_40/Y
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_97 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_86 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_75 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_42 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_20 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_31 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_53 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_64 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_8_41 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_52 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_30 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__fill_8_63 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_8
Xsky130_fd_sc_hd__dfxtp_1_3 sky130_fd_sc_hd__inv_1_131/A sky130_fd_sc_hd__inv_1_0/A
+ sky130_fd_sc_hd__inv_1_131/Y sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__dfxtp_1
Xsky130_fd_sc_hd__fill_1_149 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_105 sky130_fd_sc_hd__inv_1_89/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_127 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_138 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__fill_1_116 sky130_fd_sc_hd__inv_1_99/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_1
Xsky130_fd_sc_hd__inv_1_3 sky130_fd_sc_hd__inv_1_3/Y sky130_fd_sc_hd__inv_1_3/A VSUBS
+ sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_69 sky130_fd_sc_hd__inv_1_70/A sky130_fd_sc_hd__inv_1_69/A
+ VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_58 sky130_fd_sc_hd__inv_1_58/Y sky130_fd_sc_hd__inv_1_59/Y
+ VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_14 sky130_fd_sc_hd__inv_1_14/Y sky130_fd_sc_hd__inv_1_15/Y
+ VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_36 sky130_fd_sc_hd__inv_1_37/A sky130_fd_sc_hd__inv_1_36/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_47 sky130_fd_sc_hd__inv_1_48/A sky130_fd_sc_hd__inv_1_47/A
+ VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_25 sky130_fd_sc_hd__inv_1_25/Y sky130_fd_sc_hd__inv_1_25/A
+ VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__fill_2_87 VSUBS sky130_fd_sc_hd__inv_1_89/VPB VSUBS sky130_fd_sc_hd__inv_1_89/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_98 VSUBS sky130_fd_sc_hd__inv_1_99/VPB VSUBS sky130_fd_sc_hd__inv_1_99/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_76 VSUBS sky130_fd_sc_hd__inv_1_88/VPB VSUBS sky130_fd_sc_hd__inv_1_88/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_10 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_43 VSUBS sky130_fd_sc_hd__inv_1_0/VPB VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_32 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_21 VSUBS sky130_fd_sc_hd__inv_1_9/VPB VSUBS sky130_fd_sc_hd__inv_1_9/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_54 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_2_65 VSUBS sky130_fd_sc_hd__inv_1_53/VPB VSUBS sky130_fd_sc_hd__inv_1_53/VPB
+ sky130_fd_sc_hd__fill_2
Xsky130_fd_sc_hd__fill_1_0 sky130_fd_sc_hd__inv_1_0/VPB VSUBS VSUBS sky130_fd_sc_hd__inv_1_0/VPB
+ sky130_fd_sc_hd__fill_1
C13 OUT VSUBS 3.48fF
C14 sky130_fd_sc_hd__inv_1_16/Y VSUBS 11.00fF
C15 sky130_fd_sc_hd__inv_1_137/Y VSUBS 2.46fF
C16 sky130_fd_sc_hd__inv_1_9/VPB VSUBS 34.30fF
C17 sky130_fd_sc_hd__inv_1_99/VPB VSUBS 34.02fF
C18 sky130_fd_sc_hd__inv_1_88/VPB VSUBS 36.15fF
C19 sky130_fd_sc_hd__inv_1_89/VPB VSUBS 34.14fF
C20 sky130_fd_sc_hd__inv_1_134/A VSUBS 2.69fF
C21 sky130_fd_sc_hd__inv_1_53/VPB VSUBS 33.25fF
C22 sky130_fd_sc_hd__inv_1_0/VPB VSUBS 37.01fF
.ends
