.SUBCKT PT_UNIT_CELL CTRL VGND VNB VPB VPWR VREG
MTNAM1 VGND VREG VGND VNB sky130_fd_pr__nfet_g5v0d10v5 m=1 w=0.75 l=0.50
MTPAM1 VREG CTRL VPWR VPB sky130_fd_pr__pfet_g5v0d10v5 m=5 w=1.50 l=0.50
.ENDS
