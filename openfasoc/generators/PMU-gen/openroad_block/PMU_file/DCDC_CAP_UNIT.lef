VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO DCDC_CAP_UNIT
  CLASS BLOCK ;
  FOREIGN DCDC_CAP_UNIT ;
  ORIGIN 0.000 0.000 ;
  SIZE 8.495 BY 20.000 ;
  OBS
      LAYER met3 ;
        RECT 0.000 0.000 8.800 20.000 ;
      LAYER via3 ;
        RECT 8.075 19.440 8.395 19.760 ;
        RECT 8.075 19.040 8.395 19.360 ;
        RECT 8.075 18.640 8.395 18.960 ;
        RECT 8.075 18.240 8.395 18.560 ;
        RECT 8.075 17.840 8.395 18.160 ;
        RECT 8.075 17.440 8.395 17.760 ;
        RECT 8.075 17.040 8.395 17.360 ;
        RECT 8.070 16.640 8.390 16.960 ;
        RECT 8.075 16.240 8.395 16.560 ;
        RECT 8.075 15.840 8.395 16.160 ;
        RECT 8.075 15.440 8.395 15.760 ;
        RECT 8.075 15.040 8.395 15.360 ;
        RECT 8.075 14.640 8.395 14.960 ;
        RECT 8.075 14.240 8.395 14.560 ;
        RECT 8.075 13.840 8.395 14.160 ;
        RECT 8.075 13.440 8.395 13.760 ;
        RECT 8.075 13.040 8.395 13.360 ;
        RECT 8.075 12.640 8.395 12.960 ;
        RECT 8.075 12.240 8.395 12.560 ;
        RECT 8.075 11.840 8.395 12.160 ;
        RECT 8.075 11.440 8.395 11.760 ;
        RECT 8.075 11.040 8.395 11.360 ;
        RECT 8.075 10.640 8.395 10.960 ;
        RECT 8.075 10.240 8.395 10.560 ;
        RECT 8.075 9.840 8.395 10.160 ;
        RECT 8.075 9.440 8.395 9.760 ;
        RECT 8.075 9.040 8.395 9.360 ;
        RECT 8.075 8.640 8.395 8.960 ;
        RECT 8.075 8.240 8.395 8.560 ;
        RECT 8.075 7.840 8.395 8.160 ;
        RECT 8.075 7.440 8.395 7.760 ;
        RECT 8.075 7.040 8.395 7.360 ;
        RECT 8.075 6.640 8.395 6.960 ;
        RECT 8.075 6.240 8.395 6.560 ;
        RECT 8.075 5.840 8.395 6.160 ;
        RECT 8.075 5.440 8.395 5.760 ;
        RECT 8.075 5.040 8.395 5.360 ;
        RECT 8.075 4.640 8.395 4.960 ;
        RECT 8.075 4.240 8.395 4.560 ;
        RECT 8.075 3.840 8.395 4.160 ;
        RECT 8.075 3.440 8.395 3.760 ;
        RECT 8.075 3.040 8.395 3.360 ;
        RECT 8.075 2.640 8.395 2.960 ;
        RECT 8.075 2.240 8.395 2.560 ;
        RECT 8.075 1.840 8.395 2.160 ;
        RECT 8.075 1.440 8.395 1.760 ;
        RECT 8.075 1.040 8.395 1.360 ;
        RECT 8.075 0.640 8.395 0.960 ;
        RECT 8.075 0.240 8.395 0.560 ;
      LAYER met4 ;
        RECT 0.600 0.000 7.400 20.000 ;
        RECT 7.800 0.000 9.200 20.000 ;
  END
END DCDC_CAP_UNIT
END LIBRARY
