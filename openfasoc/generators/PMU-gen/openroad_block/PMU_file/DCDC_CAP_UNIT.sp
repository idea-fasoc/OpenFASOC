.subckt DCDC_CAP_UNIT BOT TOP
x0 TOP BOT sky130_fd_pr__cap_mim_m3_1 w=7 l=19
.ends DCDC_CAP_UNIT
