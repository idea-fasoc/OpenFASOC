.SUBCKT six_stage_conv VOUT SEL_H[5] SEL_H[4] SEL_H[3] SEL_H[2]
+ SEL_H[1] SEL_H[0] SEL_L[5] SEL_L[4] SEL_L[3] SEL_L[2] SEL_L[1]
+ SEL_L[0] clk0 clk0b clk1 clk1b VPWR VGND
Xgen_stage[0].gen_cap[0].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[0].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[10].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[10].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[11].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[11].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[12].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[12].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[13].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[13].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[14].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[14].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[15].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[15].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[16].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[16].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[17].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[17].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[18].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[18].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[19].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[19].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[1].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[1].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[20].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[20].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[21].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[21].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[22].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[22].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[23].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[23].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[24].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[24].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[25].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[25].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[26].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[26].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[27].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[27].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[28].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[28].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[29].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[29].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[2].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[2].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[30].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[30].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[31].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[31].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[32].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[32].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[33].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[33].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[34].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[34].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[35].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[35].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[36].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[36].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[37].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[37].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[38].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[38].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[39].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[39].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[3].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[3].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[40].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[40].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[41].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[41].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[42].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[42].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[43].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[43].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[44].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[44].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[45].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[45].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[46].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[46].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[47].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[47].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[48].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[48].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[49].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[49].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[4].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[4].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[50].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[50].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[51].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[51].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[52].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[52].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[53].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[53].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[54].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[54].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[55].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[55].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[5].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[5].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[6].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[6].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[7].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[7].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[8].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[8].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[9].u0_DCDC_CAP_UNIT y0_bot[0] y0_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_cap[9].u1_DCDC_CAP_UNIT y1_bot[0] y1_top[0] DCDC_CAP_UNIT
Xgen_stage[0].gen_conv[0].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[0] y1_top[0] y0_bot[0] y1_bot[0]
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[0].gen_conv[1].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[0] y1_top[0] y0_bot[0] y1_bot[0]
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[0].gen_conv[2].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[0] y1_top[0] y0_bot[0] y1_bot[0]
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[0].gen_conv[3].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[0] y1_top[0] y0_bot[0] y1_bot[0]
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[0].gen_conv[4].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[0] y1_top[0] y0_bot[0] y1_bot[0]
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[0].gen_conv[5].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[0] y1_top[0] y0_bot[0] y1_bot[0]
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[0].gen_conv[6].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[0] y1_top[0] y0_bot[0] y1_bot[0]
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[0].gen_conv[7].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[0] y1_top[0] y0_bot[0] y1_bot[0]
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[0].genblk1.u_DCDC_POWMUX.gen_powmux[0].powmux VGND VPWR SEL_H[0]
+ SEL_L[0] VGND gen_stage[0].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[0].genblk1.u_DCDC_POWMUX.vlow DCDC_MUX
Xgen_stage[1].gen_cap[0].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[0].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[100].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[100].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[101].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[101].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[102].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[102].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[103].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[103].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[104].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[104].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[105].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[105].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[106].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[106].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[107].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[107].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[108].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[108].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[109].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[109].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[10].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[10].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[110].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[110].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[111].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[111].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[112].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[112].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[11].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[11].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[12].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[12].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[13].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[13].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[14].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[14].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[15].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[15].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[16].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[16].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[17].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[17].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[18].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[18].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[19].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[19].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[1].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[1].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[20].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[20].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[21].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[21].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[22].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[22].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[23].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[23].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[24].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[24].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[25].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[25].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[26].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[26].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[27].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[27].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[28].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[28].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[29].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[29].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[2].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[2].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[30].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[30].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[31].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[31].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[32].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[32].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[33].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[33].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[34].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[34].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[35].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[35].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[36].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[36].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[37].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[37].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[38].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[38].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[39].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[39].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[3].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[3].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[40].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[40].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[41].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[41].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[42].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[42].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[43].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[43].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[44].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[44].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[45].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[45].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[46].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[46].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[47].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[47].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[48].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[48].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[49].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[49].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[4].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[4].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[50].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[50].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[51].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[51].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[52].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[52].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[53].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[53].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[54].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[54].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[55].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[55].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[56].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[56].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[57].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[57].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[58].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[58].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[59].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[59].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[5].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[5].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[60].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[60].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[61].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[61].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[62].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[62].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[63].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[63].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[64].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[64].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[65].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[65].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[66].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[66].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[67].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[67].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[68].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[68].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[69].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[69].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[6].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[6].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[70].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[70].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[71].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[71].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[72].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[72].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[73].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[73].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[74].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[74].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[75].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[75].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[76].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[76].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[77].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[77].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[78].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[78].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[79].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[79].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[7].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[7].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[80].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[80].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[81].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[81].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[82].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[82].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[83].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[83].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[84].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[84].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[85].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[85].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[86].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[86].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[87].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[87].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[88].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[88].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[89].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[89].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[8].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[8].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[90].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[90].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[91].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[91].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[92].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[92].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[93].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[93].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[94].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[94].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[95].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[95].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[96].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[96].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[97].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[97].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[98].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[98].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[99].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[99].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[9].u0_DCDC_CAP_UNIT y0_bot[1] y0_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_cap[9].u1_DCDC_CAP_UNIT y1_bot[1] y1_top[1] DCDC_CAP_UNIT
Xgen_stage[1].gen_conv[0].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[10].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[11].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[12].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[13].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[14].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[15].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[16].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[1].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[2].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[3].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[4].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[5].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[6].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[7].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[8].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].gen_conv[9].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[1] y1_top[1] y0_bot[1] y1_bot[1]
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[1].genblk1.u_DCDC_POWMUX.gen_powmux[0].powmux VGND VPWR SEL_H[1]
+ SEL_L[1] gen_stage[1].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[1].genblk1.u_DCDC_POWMUX.vlow DCDC_MUX
Xgen_stage[2].gen_cap[0].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[0].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[100].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[100].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[101].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[101].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[102].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[102].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[103].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[103].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[104].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[104].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[105].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[105].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[106].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[106].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[107].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[107].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[108].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[108].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[109].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[109].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[10].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[10].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[110].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[110].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[111].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[111].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[112].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[112].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[113].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[113].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[114].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[114].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[115].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[115].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[116].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[116].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[117].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[117].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[118].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[118].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[119].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[119].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[11].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[11].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[120].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[120].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[121].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[121].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[122].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[122].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[123].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[123].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[124].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[124].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[125].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[125].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[126].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[126].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[127].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[127].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[128].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[128].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[129].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[129].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[12].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[12].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[130].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[130].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[131].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[131].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[132].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[132].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[133].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[133].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[134].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[134].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[135].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[135].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[136].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[136].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[137].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[137].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[138].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[138].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[139].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[139].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[13].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[13].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[140].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[140].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[141].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[141].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[142].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[142].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[143].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[143].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[144].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[144].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[145].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[145].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[146].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[146].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[147].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[147].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[148].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[148].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[149].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[149].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[14].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[14].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[150].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[150].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[151].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[151].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[152].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[152].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[153].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[153].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[154].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[154].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[155].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[155].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[156].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[156].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[157].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[157].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[158].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[158].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[159].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[159].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[15].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[15].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[160].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[160].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[161].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[161].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[162].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[162].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[163].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[163].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[164].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[164].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[165].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[165].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[166].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[166].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[167].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[167].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[168].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[168].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[169].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[169].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[16].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[16].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[170].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[170].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[171].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[171].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[172].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[172].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[173].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[173].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[174].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[174].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[175].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[175].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[176].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[176].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[177].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[177].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[178].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[178].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[179].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[179].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[17].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[17].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[180].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[180].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[181].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[181].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[182].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[182].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[183].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[183].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[184].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[184].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[185].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[185].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[186].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[186].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[187].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[187].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[188].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[188].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[189].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[189].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[18].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[18].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[190].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[190].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[191].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[191].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[192].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[192].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[193].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[193].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[194].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[194].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[195].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[195].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[196].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[196].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[197].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[197].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[198].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[198].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[199].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[199].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[19].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[19].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[1].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[1].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[200].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[200].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[201].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[201].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[202].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[202].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[203].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[203].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[204].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[204].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[205].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[205].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[206].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[206].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[207].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[207].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[208].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[208].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[209].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[209].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[20].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[20].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[210].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[210].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[211].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[211].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[212].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[212].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[213].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[213].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[214].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[214].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[215].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[215].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[216].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[216].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[217].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[217].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[218].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[218].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[219].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[219].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[21].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[21].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[220].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[220].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[221].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[221].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[222].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[222].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[223].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[223].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[224].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[224].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[225].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[225].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[22].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[22].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[23].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[23].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[24].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[24].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[25].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[25].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[26].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[26].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[27].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[27].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[28].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[28].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[29].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[29].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[2].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[2].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[30].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[30].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[31].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[31].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[32].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[32].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[33].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[33].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[34].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[34].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[35].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[35].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[36].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[36].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[37].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[37].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[38].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[38].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[39].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[39].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[3].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[3].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[40].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[40].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[41].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[41].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[42].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[42].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[43].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[43].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[44].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[44].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[45].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[45].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[46].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[46].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[47].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[47].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[48].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[48].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[49].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[49].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[4].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[4].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[50].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[50].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[51].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[51].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[52].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[52].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[53].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[53].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[54].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[54].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[55].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[55].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[56].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[56].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[57].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[57].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[58].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[58].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[59].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[59].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[5].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[5].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[60].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[60].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[61].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[61].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[62].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[62].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[63].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[63].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[64].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[64].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[65].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[65].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[66].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[66].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[67].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[67].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[68].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[68].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[69].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[69].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[6].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[6].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[70].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[70].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[71].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[71].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[72].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[72].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[73].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[73].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[74].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[74].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[75].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[75].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[76].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[76].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[77].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[77].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[78].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[78].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[79].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[79].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[7].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[7].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[80].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[80].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[81].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[81].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[82].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[82].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[83].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[83].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[84].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[84].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[85].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[85].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[86].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[86].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[87].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[87].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[88].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[88].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[89].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[89].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[8].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[8].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[90].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[90].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[91].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[91].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[92].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[92].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[93].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[93].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[94].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[94].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[95].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[95].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[96].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[96].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[97].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[97].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[98].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[98].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[99].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[99].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[9].u0_DCDC_CAP_UNIT y0_bot[2] y0_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_cap[9].u1_DCDC_CAP_UNIT y1_bot[2] y1_top[2] DCDC_CAP_UNIT
Xgen_stage[2].gen_conv[0].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[10].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[11].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[12].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[13].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[14].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[15].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[16].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[17].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[18].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[19].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[1].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[20].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[21].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[22].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[23].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[24].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[25].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[26].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[27].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[28].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[29].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[2].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[30].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[31].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[32].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[33].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[3].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[4].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[5].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[6].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[7].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[8].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].gen_conv[9].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[2] y1_top[2] y0_bot[2] y1_bot[2]
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[2].genblk1.u_DCDC_POWMUX.gen_powmux[0].powmux VGND VPWR SEL_H[2]
+ SEL_L[2] gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_MUX
Xgen_stage[2].genblk1.u_DCDC_POWMUX.gen_powmux[1].powmux VGND VPWR SEL_H[2]
+ SEL_L[2] gen_stage[2].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[2].genblk1.u_DCDC_POWMUX.vlow DCDC_MUX
Xgen_stage[3].gen_cap[0].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[0].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[100].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[100].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[101].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[101].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[102].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[102].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[103].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[103].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[104].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[104].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[105].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[105].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[106].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[106].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[107].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[107].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[108].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[108].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[109].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[109].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[10].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[10].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[110].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[110].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[111].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[111].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[112].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[112].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[113].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[113].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[114].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[114].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[115].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[115].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[116].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[116].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[117].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[117].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[118].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[118].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[119].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[119].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[11].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[11].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[120].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[120].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[121].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[121].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[122].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[122].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[123].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[123].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[124].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[124].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[125].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[125].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[126].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[126].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[127].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[127].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[128].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[128].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[129].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[129].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[12].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[12].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[130].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[130].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[131].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[131].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[132].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[132].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[133].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[133].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[134].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[134].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[135].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[135].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[136].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[136].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[137].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[137].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[138].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[138].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[139].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[139].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[13].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[13].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[140].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[140].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[141].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[141].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[142].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[142].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[143].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[143].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[144].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[144].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[145].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[145].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[146].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[146].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[147].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[147].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[148].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[148].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[149].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[149].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[14].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[14].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[150].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[150].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[151].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[151].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[152].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[152].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[153].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[153].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[154].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[154].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[155].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[155].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[156].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[156].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[157].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[157].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[158].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[158].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[159].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[159].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[15].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[15].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[160].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[160].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[161].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[161].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[162].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[162].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[163].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[163].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[164].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[164].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[165].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[165].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[166].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[166].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[167].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[167].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[168].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[168].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[169].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[169].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[16].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[16].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[170].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[170].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[171].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[171].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[172].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[172].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[173].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[173].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[174].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[174].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[175].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[175].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[176].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[176].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[177].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[177].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[178].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[178].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[179].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[179].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[17].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[17].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[180].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[180].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[181].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[181].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[182].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[182].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[183].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[183].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[184].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[184].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[185].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[185].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[186].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[186].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[187].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[187].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[188].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[188].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[189].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[189].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[18].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[18].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[190].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[190].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[191].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[191].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[192].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[192].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[193].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[193].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[194].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[194].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[195].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[195].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[196].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[196].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[197].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[197].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[198].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[198].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[199].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[199].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[19].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[19].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[1].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[1].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[200].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[200].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[201].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[201].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[202].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[202].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[203].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[203].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[204].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[204].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[205].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[205].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[206].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[206].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[207].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[207].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[208].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[208].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[209].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[209].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[20].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[20].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[210].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[210].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[211].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[211].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[212].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[212].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[213].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[213].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[214].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[214].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[215].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[215].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[216].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[216].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[217].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[217].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[218].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[218].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[219].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[219].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[21].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[21].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[220].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[220].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[221].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[221].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[222].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[222].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[223].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[223].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[224].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[224].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[225].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[225].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[226].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[226].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[227].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[227].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[228].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[228].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[229].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[229].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[22].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[22].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[230].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[230].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[231].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[231].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[232].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[232].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[233].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[233].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[234].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[234].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[235].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[235].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[236].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[236].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[237].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[237].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[238].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[238].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[239].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[239].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[23].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[23].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[240].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[240].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[241].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[241].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[242].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[242].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[243].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[243].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[244].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[244].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[245].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[245].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[246].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[246].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[247].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[247].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[248].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[248].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[249].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[249].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[24].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[24].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[250].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[250].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[251].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[251].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[252].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[252].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[253].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[253].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[254].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[254].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[255].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[255].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[256].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[256].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[257].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[257].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[258].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[258].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[259].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[259].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[25].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[25].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[260].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[260].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[261].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[261].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[262].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[262].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[263].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[263].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[264].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[264].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[265].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[265].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[266].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[266].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[267].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[267].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[268].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[268].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[269].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[269].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[26].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[26].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[270].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[270].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[271].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[271].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[272].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[272].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[273].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[273].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[274].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[274].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[275].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[275].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[276].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[276].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[277].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[277].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[278].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[278].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[279].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[279].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[27].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[27].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[280].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[280].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[281].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[281].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[282].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[282].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[283].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[283].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[284].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[284].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[285].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[285].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[286].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[286].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[287].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[287].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[288].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[288].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[289].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[289].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[28].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[28].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[290].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[290].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[291].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[291].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[292].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[292].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[293].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[293].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[294].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[294].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[295].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[295].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[296].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[296].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[297].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[297].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[298].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[298].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[299].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[299].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[29].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[29].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[2].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[2].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[300].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[300].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[301].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[301].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[302].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[302].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[303].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[303].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[304].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[304].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[305].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[305].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[306].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[306].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[307].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[307].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[308].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[308].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[309].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[309].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[30].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[30].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[310].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[310].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[311].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[311].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[312].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[312].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[313].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[313].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[314].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[314].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[315].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[315].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[316].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[316].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[317].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[317].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[318].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[318].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[319].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[319].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[31].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[31].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[320].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[320].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[321].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[321].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[322].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[322].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[323].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[323].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[324].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[324].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[325].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[325].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[326].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[326].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[327].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[327].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[328].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[328].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[329].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[329].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[32].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[32].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[330].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[330].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[331].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[331].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[332].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[332].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[333].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[333].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[334].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[334].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[335].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[335].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[336].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[336].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[337].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[337].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[338].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[338].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[339].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[339].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[33].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[33].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[340].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[340].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[341].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[341].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[342].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[342].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[343].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[343].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[344].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[344].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[345].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[345].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[346].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[346].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[347].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[347].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[348].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[348].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[349].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[349].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[34].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[34].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[350].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[350].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[351].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[351].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[352].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[352].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[353].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[353].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[354].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[354].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[355].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[355].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[356].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[356].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[357].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[357].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[358].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[358].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[359].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[359].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[35].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[35].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[360].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[360].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[361].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[361].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[362].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[362].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[363].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[363].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[364].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[364].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[365].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[365].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[366].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[366].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[367].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[367].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[368].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[368].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[369].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[369].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[36].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[36].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[370].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[370].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[371].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[371].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[372].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[372].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[373].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[373].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[374].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[374].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[375].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[375].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[376].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[376].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[377].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[377].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[378].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[378].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[379].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[379].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[37].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[37].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[380].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[380].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[381].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[381].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[382].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[382].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[383].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[383].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[384].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[384].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[385].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[385].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[386].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[386].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[387].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[387].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[388].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[388].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[389].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[389].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[38].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[38].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[390].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[390].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[391].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[391].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[392].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[392].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[393].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[393].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[394].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[394].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[395].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[395].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[396].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[396].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[397].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[397].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[398].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[398].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[399].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[399].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[39].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[39].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[3].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[3].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[400].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[400].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[401].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[401].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[402].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[402].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[403].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[403].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[404].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[404].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[405].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[405].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[406].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[406].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[407].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[407].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[408].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[408].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[409].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[409].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[40].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[40].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[410].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[410].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[411].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[411].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[412].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[412].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[413].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[413].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[414].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[414].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[415].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[415].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[416].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[416].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[417].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[417].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[418].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[418].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[419].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[419].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[41].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[41].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[420].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[420].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[421].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[421].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[422].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[422].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[423].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[423].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[424].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[424].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[425].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[425].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[426].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[426].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[427].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[427].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[428].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[428].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[429].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[429].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[42].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[42].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[430].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[430].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[431].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[431].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[432].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[432].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[433].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[433].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[434].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[434].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[435].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[435].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[436].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[436].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[437].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[437].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[438].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[438].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[439].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[439].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[43].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[43].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[440].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[440].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[441].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[441].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[442].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[442].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[443].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[443].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[444].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[444].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[445].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[445].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[446].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[446].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[447].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[447].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[448].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[448].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[449].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[449].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[44].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[44].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[450].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[450].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[451].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[451].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[452].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[452].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[45].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[45].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[46].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[46].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[47].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[47].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[48].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[48].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[49].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[49].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[4].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[4].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[50].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[50].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[51].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[51].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[52].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[52].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[53].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[53].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[54].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[54].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[55].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[55].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[56].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[56].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[57].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[57].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[58].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[58].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[59].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[59].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[5].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[5].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[60].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[60].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[61].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[61].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[62].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[62].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[63].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[63].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[64].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[64].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[65].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[65].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[66].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[66].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[67].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[67].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[68].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[68].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[69].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[69].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[6].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[6].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[70].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[70].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[71].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[71].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[72].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[72].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[73].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[73].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[74].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[74].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[75].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[75].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[76].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[76].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[77].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[77].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[78].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[78].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[79].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[79].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[7].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[7].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[80].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[80].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[81].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[81].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[82].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[82].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[83].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[83].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[84].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[84].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[85].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[85].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[86].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[86].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[87].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[87].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[88].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[88].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[89].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[89].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[8].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[8].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[90].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[90].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[91].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[91].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[92].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[92].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[93].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[93].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[94].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[94].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[95].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[95].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[96].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[96].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[97].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[97].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[98].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[98].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[99].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[99].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[9].u0_DCDC_CAP_UNIT y0_bot[3] y0_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_cap[9].u1_DCDC_CAP_UNIT y1_bot[3] y1_top[3] DCDC_CAP_UNIT
Xgen_stage[3].gen_conv[0].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[10].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[11].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[12].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[13].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[14].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[15].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[16].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[17].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[18].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[19].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[1].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[20].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[21].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[22].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[23].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[24].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[25].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[26].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[27].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[28].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[29].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[2].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[30].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[31].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[32].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[33].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[34].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[35].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[36].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[37].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[38].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[39].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[3].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[40].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[41].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[42].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[43].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[44].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[45].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[46].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[47].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[48].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[49].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[4].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[50].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[51].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[52].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[53].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[54].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[55].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[56].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[57].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[58].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[59].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[5].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[60].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[61].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[62].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[63].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[64].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[65].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[66].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[67].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[6].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[7].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[8].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].gen_conv[9].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[3] y1_top[3] y0_bot[3] y1_bot[3]
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[3].genblk1.u_DCDC_POWMUX.gen_powmux[0].powmux VGND VPWR SEL_H[3]
+ SEL_L[3] gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_MUX
Xgen_stage[3].genblk1.u_DCDC_POWMUX.gen_powmux[1].powmux VGND VPWR SEL_H[3]
+ SEL_L[3] gen_stage[3].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[3].genblk1.u_DCDC_POWMUX.vlow DCDC_MUX
Xgen_stage[4].gen_cap[0].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[0].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[100].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[100].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[101].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[101].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[102].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[102].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[103].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[103].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[104].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[104].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[105].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[105].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[106].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[106].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[107].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[107].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[108].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[108].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[109].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[109].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[10].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[10].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[110].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[110].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[111].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[111].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[112].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[112].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[113].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[113].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[114].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[114].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[115].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[115].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[116].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[116].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[117].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[117].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[118].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[118].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[119].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[119].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[11].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[11].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[120].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[120].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[121].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[121].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[122].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[122].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[123].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[123].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[124].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[124].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[125].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[125].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[126].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[126].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[127].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[127].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[128].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[128].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[129].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[129].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[12].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[12].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[130].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[130].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[131].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[131].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[132].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[132].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[133].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[133].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[134].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[134].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[135].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[135].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[136].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[136].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[137].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[137].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[138].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[138].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[139].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[139].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[13].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[13].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[140].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[140].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[141].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[141].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[142].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[142].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[143].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[143].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[144].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[144].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[145].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[145].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[146].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[146].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[147].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[147].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[148].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[148].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[149].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[149].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[14].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[14].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[150].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[150].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[151].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[151].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[152].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[152].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[153].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[153].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[154].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[154].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[155].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[155].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[156].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[156].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[157].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[157].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[158].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[158].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[159].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[159].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[15].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[15].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[160].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[160].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[161].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[161].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[162].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[162].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[163].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[163].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[164].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[164].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[165].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[165].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[166].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[166].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[167].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[167].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[168].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[168].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[169].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[169].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[16].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[16].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[170].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[170].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[171].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[171].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[172].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[172].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[173].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[173].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[174].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[174].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[175].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[175].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[176].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[176].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[177].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[177].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[178].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[178].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[179].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[179].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[17].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[17].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[180].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[180].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[181].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[181].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[182].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[182].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[183].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[183].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[184].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[184].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[185].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[185].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[186].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[186].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[187].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[187].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[188].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[188].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[189].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[189].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[18].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[18].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[190].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[190].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[191].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[191].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[192].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[192].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[193].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[193].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[194].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[194].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[195].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[195].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[196].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[196].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[197].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[197].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[198].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[198].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[199].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[199].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[19].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[19].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[1].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[1].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[200].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[200].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[201].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[201].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[202].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[202].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[203].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[203].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[204].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[204].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[205].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[205].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[206].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[206].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[207].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[207].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[208].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[208].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[209].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[209].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[20].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[20].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[210].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[210].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[211].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[211].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[212].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[212].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[213].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[213].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[214].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[214].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[215].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[215].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[216].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[216].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[217].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[217].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[218].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[218].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[219].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[219].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[21].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[21].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[220].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[220].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[221].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[221].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[222].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[222].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[223].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[223].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[224].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[224].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[225].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[225].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[226].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[226].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[227].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[227].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[228].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[228].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[229].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[229].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[22].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[22].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[230].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[230].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[231].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[231].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[232].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[232].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[233].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[233].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[234].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[234].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[235].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[235].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[236].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[236].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[237].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[237].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[238].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[238].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[239].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[239].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[23].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[23].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[240].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[240].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[241].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[241].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[242].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[242].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[243].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[243].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[244].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[244].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[245].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[245].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[246].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[246].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[247].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[247].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[248].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[248].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[249].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[249].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[24].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[24].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[250].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[250].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[251].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[251].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[252].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[252].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[253].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[253].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[254].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[254].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[255].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[255].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[256].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[256].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[257].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[257].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[258].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[258].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[259].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[259].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[25].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[25].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[260].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[260].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[261].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[261].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[262].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[262].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[263].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[263].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[264].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[264].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[265].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[265].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[266].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[266].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[267].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[267].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[268].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[268].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[269].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[269].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[26].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[26].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[270].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[270].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[271].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[271].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[272].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[272].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[273].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[273].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[274].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[274].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[275].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[275].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[276].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[276].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[277].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[277].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[278].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[278].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[279].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[279].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[27].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[27].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[280].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[280].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[281].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[281].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[282].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[282].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[283].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[283].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[284].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[284].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[285].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[285].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[286].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[286].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[287].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[287].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[288].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[288].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[289].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[289].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[28].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[28].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[290].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[290].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[291].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[291].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[292].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[292].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[293].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[293].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[294].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[294].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[295].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[295].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[296].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[296].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[297].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[297].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[298].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[298].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[299].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[299].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[29].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[29].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[2].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[2].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[300].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[300].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[301].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[301].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[302].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[302].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[303].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[303].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[304].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[304].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[305].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[305].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[306].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[306].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[307].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[307].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[308].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[308].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[309].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[309].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[30].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[30].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[310].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[310].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[311].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[311].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[312].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[312].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[313].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[313].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[314].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[314].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[315].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[315].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[316].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[316].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[317].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[317].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[318].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[318].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[319].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[319].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[31].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[31].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[320].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[320].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[321].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[321].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[322].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[322].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[323].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[323].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[324].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[324].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[325].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[325].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[326].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[326].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[327].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[327].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[328].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[328].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[329].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[329].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[32].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[32].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[330].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[330].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[331].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[331].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[332].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[332].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[333].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[333].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[334].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[334].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[335].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[335].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[336].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[336].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[337].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[337].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[338].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[338].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[339].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[339].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[33].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[33].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[340].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[340].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[341].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[341].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[342].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[342].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[343].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[343].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[344].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[344].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[345].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[345].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[346].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[346].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[347].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[347].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[348].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[348].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[349].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[349].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[34].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[34].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[350].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[350].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[351].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[351].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[352].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[352].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[353].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[353].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[354].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[354].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[355].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[355].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[356].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[356].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[357].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[357].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[358].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[358].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[359].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[359].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[35].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[35].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[360].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[360].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[361].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[361].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[362].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[362].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[363].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[363].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[364].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[364].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[365].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[365].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[366].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[366].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[367].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[367].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[368].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[368].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[369].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[369].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[36].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[36].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[370].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[370].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[371].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[371].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[372].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[372].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[373].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[373].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[374].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[374].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[375].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[375].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[376].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[376].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[377].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[377].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[378].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[378].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[379].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[379].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[37].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[37].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[380].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[380].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[381].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[381].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[382].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[382].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[383].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[383].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[384].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[384].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[385].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[385].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[386].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[386].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[387].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[387].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[388].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[388].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[389].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[389].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[38].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[38].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[390].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[390].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[391].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[391].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[392].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[392].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[393].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[393].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[394].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[394].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[395].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[395].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[396].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[396].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[397].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[397].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[398].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[398].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[399].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[399].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[39].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[39].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[3].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[3].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[400].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[400].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[401].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[401].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[402].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[402].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[403].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[403].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[404].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[404].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[405].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[405].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[406].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[406].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[407].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[407].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[408].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[408].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[409].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[409].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[40].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[40].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[410].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[410].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[411].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[411].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[412].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[412].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[413].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[413].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[414].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[414].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[415].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[415].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[416].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[416].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[417].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[417].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[418].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[418].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[419].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[419].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[41].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[41].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[420].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[420].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[421].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[421].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[422].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[422].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[423].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[423].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[424].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[424].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[425].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[425].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[426].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[426].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[427].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[427].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[428].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[428].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[429].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[429].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[42].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[42].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[430].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[430].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[431].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[431].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[432].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[432].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[433].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[433].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[434].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[434].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[435].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[435].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[436].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[436].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[437].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[437].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[438].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[438].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[439].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[439].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[43].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[43].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[440].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[440].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[441].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[441].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[442].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[442].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[443].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[443].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[444].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[444].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[445].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[445].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[446].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[446].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[447].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[447].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[448].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[448].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[449].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[449].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[44].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[44].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[450].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[450].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[451].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[451].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[452].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[452].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[453].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[453].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[454].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[454].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[455].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[455].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[456].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[456].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[457].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[457].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[458].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[458].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[459].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[459].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[45].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[45].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[460].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[460].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[461].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[461].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[462].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[462].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[463].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[463].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[464].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[464].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[465].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[465].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[466].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[466].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[467].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[467].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[468].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[468].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[469].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[469].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[46].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[46].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[470].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[470].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[471].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[471].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[472].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[472].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[473].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[473].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[474].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[474].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[475].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[475].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[476].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[476].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[477].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[477].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[478].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[478].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[479].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[479].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[47].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[47].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[480].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[480].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[481].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[481].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[482].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[482].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[483].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[483].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[484].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[484].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[485].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[485].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[486].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[486].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[487].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[487].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[488].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[488].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[489].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[489].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[48].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[48].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[490].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[490].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[491].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[491].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[492].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[492].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[493].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[493].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[494].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[494].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[495].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[495].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[496].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[496].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[497].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[497].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[498].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[498].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[499].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[499].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[49].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[49].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[4].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[4].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[500].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[500].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[501].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[501].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[502].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[502].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[503].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[503].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[504].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[504].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[505].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[505].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[506].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[506].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[507].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[507].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[508].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[508].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[509].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[509].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[50].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[50].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[510].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[510].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[511].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[511].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[512].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[512].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[513].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[513].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[514].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[514].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[515].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[515].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[516].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[516].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[517].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[517].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[518].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[518].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[519].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[519].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[51].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[51].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[520].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[520].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[521].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[521].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[522].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[522].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[523].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[523].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[524].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[524].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[525].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[525].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[526].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[526].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[527].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[527].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[528].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[528].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[529].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[529].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[52].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[52].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[530].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[530].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[531].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[531].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[532].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[532].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[533].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[533].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[534].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[534].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[535].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[535].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[536].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[536].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[537].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[537].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[538].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[538].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[539].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[539].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[53].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[53].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[540].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[540].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[541].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[541].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[542].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[542].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[543].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[543].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[544].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[544].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[545].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[545].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[546].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[546].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[547].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[547].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[548].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[548].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[549].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[549].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[54].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[54].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[550].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[550].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[551].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[551].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[552].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[552].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[553].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[553].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[554].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[554].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[555].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[555].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[556].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[556].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[557].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[557].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[558].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[558].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[559].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[559].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[55].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[55].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[560].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[560].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[561].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[561].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[562].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[562].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[563].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[563].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[564].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[564].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[565].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[565].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[566].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[566].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[567].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[567].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[568].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[568].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[569].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[569].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[56].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[56].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[570].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[570].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[571].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[571].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[572].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[572].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[573].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[573].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[574].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[574].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[575].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[575].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[576].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[576].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[577].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[577].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[578].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[578].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[579].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[579].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[57].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[57].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[580].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[580].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[581].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[581].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[582].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[582].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[583].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[583].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[584].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[584].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[585].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[585].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[586].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[586].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[587].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[587].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[588].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[588].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[589].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[589].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[58].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[58].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[590].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[590].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[591].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[591].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[592].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[592].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[593].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[593].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[594].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[594].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[595].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[595].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[596].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[596].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[597].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[597].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[598].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[598].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[599].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[599].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[59].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[59].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[5].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[5].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[600].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[600].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[601].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[601].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[602].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[602].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[603].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[603].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[604].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[604].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[605].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[605].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[606].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[606].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[607].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[607].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[608].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[608].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[609].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[609].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[60].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[60].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[610].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[610].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[611].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[611].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[612].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[612].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[613].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[613].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[614].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[614].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[615].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[615].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[616].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[616].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[617].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[617].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[618].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[618].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[619].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[619].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[61].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[61].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[620].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[620].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[621].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[621].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[622].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[622].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[623].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[623].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[624].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[624].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[625].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[625].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[626].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[626].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[627].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[627].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[628].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[628].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[629].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[629].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[62].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[62].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[630].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[630].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[631].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[631].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[632].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[632].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[633].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[633].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[634].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[634].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[635].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[635].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[636].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[636].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[637].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[637].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[638].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[638].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[639].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[639].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[63].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[63].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[640].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[640].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[641].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[641].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[642].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[642].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[643].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[643].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[644].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[644].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[645].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[645].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[646].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[646].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[647].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[647].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[648].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[648].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[649].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[649].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[64].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[64].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[650].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[650].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[651].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[651].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[652].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[652].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[653].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[653].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[654].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[654].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[655].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[655].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[656].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[656].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[657].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[657].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[658].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[658].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[659].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[659].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[65].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[65].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[660].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[660].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[661].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[661].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[662].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[662].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[663].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[663].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[664].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[664].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[665].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[665].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[666].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[666].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[667].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[667].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[668].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[668].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[669].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[669].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[66].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[66].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[670].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[670].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[671].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[671].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[672].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[672].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[673].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[673].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[674].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[674].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[675].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[675].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[676].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[676].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[677].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[677].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[678].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[678].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[679].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[679].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[67].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[67].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[680].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[680].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[681].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[681].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[682].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[682].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[683].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[683].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[684].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[684].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[685].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[685].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[686].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[686].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[687].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[687].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[688].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[688].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[689].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[689].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[68].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[68].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[690].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[690].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[691].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[691].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[692].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[692].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[693].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[693].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[694].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[694].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[695].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[695].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[696].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[696].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[697].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[697].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[698].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[698].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[699].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[699].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[69].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[69].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[6].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[6].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[700].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[700].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[701].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[701].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[702].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[702].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[703].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[703].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[704].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[704].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[705].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[705].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[706].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[706].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[707].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[707].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[708].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[708].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[709].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[709].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[70].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[70].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[710].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[710].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[711].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[711].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[712].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[712].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[713].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[713].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[714].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[714].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[715].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[715].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[716].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[716].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[717].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[717].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[718].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[718].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[719].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[719].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[71].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[71].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[720].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[720].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[721].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[721].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[722].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[722].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[723].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[723].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[724].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[724].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[725].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[725].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[726].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[726].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[727].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[727].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[728].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[728].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[729].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[729].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[72].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[72].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[730].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[730].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[731].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[731].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[732].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[732].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[733].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[733].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[734].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[734].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[735].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[735].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[736].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[736].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[737].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[737].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[738].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[738].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[739].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[739].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[73].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[73].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[740].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[740].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[741].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[741].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[742].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[742].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[743].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[743].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[744].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[744].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[745].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[745].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[746].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[746].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[747].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[747].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[748].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[748].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[749].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[749].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[74].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[74].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[750].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[750].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[751].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[751].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[752].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[752].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[753].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[753].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[754].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[754].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[755].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[755].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[756].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[756].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[757].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[757].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[758].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[758].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[759].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[759].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[75].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[75].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[760].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[760].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[761].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[761].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[762].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[762].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[763].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[763].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[764].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[764].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[765].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[765].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[766].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[766].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[767].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[767].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[768].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[768].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[769].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[769].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[76].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[76].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[770].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[770].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[771].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[771].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[772].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[772].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[773].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[773].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[774].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[774].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[775].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[775].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[776].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[776].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[777].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[777].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[778].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[778].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[779].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[779].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[77].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[77].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[780].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[780].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[781].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[781].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[782].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[782].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[783].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[783].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[784].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[784].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[785].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[785].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[786].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[786].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[787].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[787].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[788].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[788].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[789].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[789].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[78].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[78].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[790].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[790].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[791].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[791].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[792].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[792].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[793].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[793].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[794].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[794].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[795].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[795].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[796].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[796].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[797].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[797].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[798].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[798].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[799].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[799].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[79].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[79].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[7].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[7].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[800].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[800].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[801].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[801].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[802].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[802].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[803].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[803].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[804].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[804].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[805].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[805].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[806].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[806].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[807].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[807].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[808].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[808].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[809].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[809].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[80].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[80].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[810].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[810].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[811].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[811].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[812].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[812].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[813].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[813].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[814].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[814].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[815].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[815].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[816].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[816].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[817].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[817].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[818].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[818].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[819].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[819].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[81].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[81].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[820].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[820].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[821].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[821].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[822].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[822].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[823].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[823].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[824].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[824].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[825].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[825].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[826].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[826].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[827].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[827].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[828].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[828].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[829].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[829].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[82].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[82].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[830].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[830].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[831].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[831].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[832].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[832].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[833].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[833].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[834].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[834].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[835].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[835].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[836].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[836].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[837].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[837].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[838].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[838].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[839].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[839].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[83].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[83].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[840].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[840].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[841].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[841].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[842].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[842].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[843].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[843].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[844].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[844].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[845].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[845].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[846].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[846].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[847].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[847].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[848].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[848].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[849].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[849].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[84].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[84].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[850].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[850].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[851].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[851].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[852].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[852].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[853].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[853].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[854].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[854].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[855].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[855].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[856].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[856].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[857].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[857].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[858].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[858].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[859].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[859].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[85].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[85].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[860].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[860].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[861].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[861].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[862].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[862].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[863].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[863].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[864].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[864].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[865].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[865].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[866].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[866].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[867].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[867].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[868].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[868].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[869].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[869].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[86].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[86].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[870].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[870].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[871].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[871].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[872].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[872].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[873].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[873].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[874].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[874].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[875].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[875].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[876].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[876].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[877].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[877].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[878].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[878].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[879].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[879].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[87].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[87].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[880].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[880].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[881].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[881].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[882].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[882].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[883].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[883].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[884].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[884].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[885].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[885].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[886].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[886].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[887].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[887].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[888].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[888].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[889].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[889].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[88].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[88].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[890].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[890].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[891].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[891].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[892].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[892].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[893].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[893].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[894].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[894].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[895].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[895].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[896].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[896].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[897].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[897].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[898].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[898].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[899].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[899].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[89].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[89].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[8].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[8].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[900].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[900].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[901].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[901].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[902].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[902].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[903].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[903].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[904].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[904].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[905].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[905].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[90].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[90].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[91].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[91].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[92].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[92].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[93].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[93].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[94].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[94].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[95].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[95].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[96].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[96].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[97].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[97].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[98].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[98].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[99].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[99].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[9].u0_DCDC_CAP_UNIT y0_bot[4] y0_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_cap[9].u1_DCDC_CAP_UNIT y1_bot[4] y1_top[4] DCDC_CAP_UNIT
Xgen_stage[4].gen_conv[0].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[100].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[101].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[102].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[103].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[104].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[105].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[106].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[107].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[108].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[109].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[10].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[110].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[111].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[112].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[113].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[114].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[115].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[116].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[117].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[118].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[119].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[11].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[120].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[121].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[122].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[123].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[124].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[125].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[126].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[127].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[128].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[129].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[12].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[130].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[131].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[132].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[133].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[134].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[135].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[136].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[13].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[14].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[15].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[16].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[17].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[18].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[19].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[1].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[20].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[21].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[22].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[23].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[24].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[25].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[26].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[27].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[28].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[29].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[2].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[30].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[31].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[32].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[33].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[34].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[35].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[36].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[37].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[38].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[39].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[3].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[40].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[41].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[42].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[43].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[44].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[45].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[46].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[47].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[48].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[49].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[4].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[50].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[51].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[52].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[53].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[54].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[55].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[56].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[57].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[58].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[59].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[5].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[60].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[61].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[62].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[63].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[64].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[65].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[66].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[67].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[68].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[69].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[6].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[70].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[71].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[72].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[73].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[74].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[75].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[76].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[77].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[78].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[79].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[7].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[80].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[81].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[82].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[83].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[84].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[85].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[86].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[87].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[88].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[89].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[8].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[90].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[91].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[92].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[93].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[94].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[95].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[96].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[97].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[98].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[99].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].gen_conv[9].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[4] y1_top[4] y0_bot[4] y1_bot[4]
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[4].genblk1.u_DCDC_POWMUX.gen_powmux[0].powmux VGND VPWR SEL_H[4]
+ SEL_L[4] gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_MUX
Xgen_stage[4].genblk1.u_DCDC_POWMUX.gen_powmux[1].powmux VGND VPWR SEL_H[4]
+ SEL_L[4] gen_stage[4].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[4].genblk1.u_DCDC_POWMUX.vlow DCDC_MUX
Xgen_stage[5].gen_cap[0].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[0].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1000].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1000].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1001].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1001].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1002].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1002].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1003].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1003].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1004].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1004].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1005].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1005].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1006].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1006].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1007].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1007].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1008].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1008].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1009].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1009].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[100].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[100].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1010].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1010].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1011].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1011].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1012].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1012].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1013].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1013].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1014].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1014].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1015].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1015].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1016].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1016].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1017].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1017].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1018].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1018].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1019].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1019].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[101].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[101].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1020].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1020].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1021].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1021].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1022].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1022].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1023].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1023].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1024].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1024].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1025].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1025].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1026].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1026].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1027].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1027].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1028].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1028].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1029].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1029].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[102].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[102].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1030].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1030].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1031].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1031].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1032].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1032].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1033].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1033].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1034].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1034].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1035].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1035].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1036].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1036].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1037].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1037].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1038].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1038].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1039].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1039].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[103].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[103].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1040].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1040].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1041].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1041].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1042].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1042].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1043].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1043].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1044].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1044].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1045].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1045].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1046].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1046].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1047].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1047].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1048].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1048].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1049].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1049].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[104].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[104].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1050].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1050].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1051].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1051].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1052].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1052].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1053].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1053].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1054].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1054].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1055].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1055].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1056].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1056].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1057].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1057].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1058].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1058].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1059].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1059].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[105].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[105].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1060].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1060].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1061].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1061].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1062].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1062].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1063].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1063].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1064].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1064].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1065].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1065].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1066].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1066].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1067].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1067].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1068].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1068].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1069].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1069].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[106].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[106].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1070].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1070].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1071].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1071].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1072].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1072].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1073].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1073].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1074].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1074].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1075].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1075].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1076].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1076].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1077].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1077].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1078].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1078].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1079].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1079].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[107].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[107].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1080].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1080].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1081].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1081].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1082].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1082].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1083].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1083].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1084].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1084].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1085].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1085].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1086].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1086].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1087].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1087].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1088].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1088].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1089].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1089].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[108].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[108].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1090].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1090].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1091].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1091].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1092].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1092].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1093].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1093].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1094].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1094].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1095].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1095].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1096].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1096].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1097].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1097].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1098].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1098].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1099].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1099].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[109].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[109].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[10].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[10].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1100].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1100].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1101].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1101].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1102].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1102].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1103].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1103].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1104].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1104].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1105].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1105].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1106].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1106].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1107].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1107].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1108].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1108].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1109].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1109].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[110].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[110].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1110].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1110].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1111].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1111].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1112].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1112].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1113].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1113].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1114].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1114].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1115].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1115].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1116].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1116].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1117].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1117].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1118].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1118].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1119].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1119].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[111].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[111].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1120].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1120].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1121].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1121].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1122].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1122].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1123].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1123].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1124].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1124].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1125].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1125].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1126].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1126].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1127].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1127].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1128].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1128].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1129].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1129].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[112].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[112].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1130].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1130].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1131].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1131].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1132].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1132].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1133].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1133].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1134].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1134].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1135].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1135].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1136].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1136].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1137].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1137].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1138].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1138].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1139].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1139].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[113].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[113].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1140].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1140].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1141].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1141].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1142].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1142].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1143].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1143].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1144].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1144].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1145].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1145].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1146].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1146].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1147].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1147].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1148].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1148].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1149].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1149].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[114].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[114].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1150].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1150].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1151].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1151].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1152].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1152].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1153].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1153].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1154].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1154].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1155].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1155].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1156].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1156].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1157].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1157].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1158].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1158].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1159].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1159].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[115].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[115].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1160].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1160].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1161].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1161].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1162].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1162].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1163].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1163].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1164].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1164].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1165].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1165].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1166].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1166].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1167].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1167].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1168].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1168].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1169].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1169].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[116].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[116].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1170].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1170].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1171].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1171].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1172].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1172].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1173].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1173].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1174].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1174].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1175].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1175].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1176].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1176].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1177].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1177].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1178].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1178].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1179].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1179].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[117].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[117].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1180].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1180].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1181].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1181].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1182].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1182].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1183].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1183].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1184].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1184].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1185].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1185].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1186].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1186].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1187].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1187].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1188].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1188].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1189].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1189].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[118].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[118].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1190].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1190].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1191].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1191].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1192].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1192].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1193].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1193].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1194].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1194].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1195].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1195].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1196].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1196].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1197].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1197].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1198].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1198].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1199].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1199].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[119].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[119].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[11].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[11].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1200].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1200].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1201].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1201].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1202].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1202].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1203].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1203].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1204].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1204].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1205].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1205].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1206].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1206].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1207].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1207].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1208].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1208].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1209].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1209].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[120].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[120].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1210].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1210].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1211].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1211].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1212].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1212].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1213].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1213].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1214].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1214].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1215].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1215].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1216].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1216].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1217].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1217].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1218].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1218].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1219].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1219].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[121].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[121].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1220].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1220].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1221].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1221].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1222].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1222].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1223].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1223].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1224].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1224].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1225].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1225].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1226].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1226].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1227].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1227].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1228].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1228].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1229].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1229].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[122].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[122].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1230].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1230].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1231].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1231].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1232].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1232].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1233].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1233].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1234].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1234].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1235].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1235].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1236].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1236].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1237].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1237].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1238].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1238].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1239].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1239].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[123].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[123].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1240].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1240].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1241].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1241].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1242].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1242].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1243].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1243].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1244].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1244].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1245].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1245].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1246].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1246].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1247].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1247].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1248].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1248].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1249].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1249].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[124].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[124].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1250].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1250].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1251].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1251].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1252].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1252].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1253].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1253].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1254].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1254].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1255].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1255].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1256].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1256].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1257].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1257].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1258].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1258].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1259].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1259].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[125].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[125].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1260].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1260].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1261].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1261].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1262].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1262].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1263].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1263].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1264].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1264].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1265].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1265].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1266].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1266].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1267].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1267].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1268].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1268].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1269].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1269].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[126].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[126].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1270].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1270].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1271].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1271].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1272].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1272].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1273].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1273].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1274].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1274].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1275].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1275].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1276].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1276].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1277].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1277].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1278].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1278].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1279].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1279].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[127].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[127].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1280].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1280].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1281].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1281].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1282].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1282].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1283].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1283].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1284].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1284].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1285].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1285].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1286].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1286].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1287].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1287].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1288].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1288].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1289].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1289].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[128].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[128].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1290].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1290].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1291].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1291].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1292].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1292].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1293].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1293].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1294].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1294].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1295].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1295].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1296].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1296].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1297].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1297].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1298].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1298].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1299].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1299].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[129].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[129].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[12].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[12].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1300].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1300].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1301].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1301].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1302].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1302].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1303].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1303].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1304].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1304].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1305].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1305].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1306].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1306].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1307].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1307].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1308].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1308].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1309].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1309].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[130].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[130].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1310].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1310].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1311].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1311].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1312].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1312].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1313].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1313].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1314].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1314].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1315].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1315].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1316].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1316].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1317].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1317].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1318].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1318].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1319].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1319].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[131].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[131].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1320].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1320].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1321].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1321].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1322].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1322].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1323].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1323].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1324].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1324].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1325].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1325].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1326].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1326].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1327].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1327].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1328].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1328].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1329].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1329].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[132].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[132].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1330].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1330].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1331].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1331].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1332].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1332].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1333].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1333].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1334].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1334].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1335].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1335].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1336].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1336].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1337].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1337].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1338].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1338].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1339].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1339].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[133].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[133].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1340].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1340].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1341].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1341].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1342].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1342].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1343].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1343].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1344].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1344].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1345].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1345].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1346].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1346].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1347].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1347].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1348].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1348].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1349].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1349].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[134].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[134].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1350].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1350].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1351].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1351].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1352].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1352].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1353].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1353].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1354].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1354].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1355].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1355].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1356].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1356].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1357].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1357].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1358].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1358].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1359].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1359].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[135].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[135].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1360].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1360].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1361].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1361].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1362].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1362].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1363].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1363].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1364].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1364].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1365].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1365].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1366].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1366].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1367].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1367].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1368].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1368].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1369].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1369].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[136].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[136].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1370].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1370].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1371].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1371].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1372].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1372].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1373].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1373].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1374].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1374].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1375].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1375].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1376].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1376].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1377].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1377].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1378].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1378].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1379].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1379].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[137].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[137].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1380].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1380].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1381].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1381].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1382].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1382].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1383].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1383].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1384].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1384].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1385].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1385].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1386].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1386].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1387].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1387].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1388].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1388].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1389].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1389].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[138].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[138].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1390].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1390].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1391].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1391].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1392].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1392].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1393].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1393].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1394].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1394].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1395].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1395].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1396].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1396].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1397].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1397].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1398].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1398].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1399].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1399].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[139].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[139].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[13].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[13].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1400].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1400].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1401].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1401].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1402].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1402].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1403].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1403].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1404].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1404].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1405].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1405].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1406].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1406].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1407].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1407].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1408].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1408].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1409].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1409].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[140].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[140].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1410].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1410].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1411].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1411].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1412].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1412].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1413].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1413].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1414].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1414].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1415].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1415].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1416].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1416].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1417].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1417].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1418].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1418].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1419].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1419].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[141].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[141].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1420].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1420].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1421].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1421].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1422].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1422].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1423].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1423].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1424].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1424].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1425].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1425].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1426].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1426].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1427].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1427].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1428].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1428].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1429].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1429].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[142].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[142].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1430].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1430].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1431].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1431].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1432].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1432].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1433].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1433].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1434].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1434].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1435].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1435].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1436].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1436].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1437].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1437].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1438].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1438].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1439].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1439].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[143].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[143].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1440].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1440].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1441].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1441].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1442].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1442].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1443].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1443].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1444].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1444].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1445].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1445].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1446].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1446].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1447].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1447].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1448].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1448].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1449].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1449].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[144].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[144].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1450].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1450].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1451].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1451].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1452].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1452].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1453].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1453].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1454].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1454].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1455].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1455].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1456].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1456].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1457].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1457].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1458].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1458].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1459].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1459].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[145].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[145].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1460].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1460].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1461].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1461].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1462].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1462].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1463].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1463].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1464].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1464].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1465].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1465].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1466].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1466].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1467].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1467].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1468].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1468].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1469].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1469].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[146].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[146].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1470].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1470].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1471].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1471].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1472].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1472].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1473].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1473].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1474].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1474].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1475].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1475].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1476].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1476].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1477].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1477].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1478].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1478].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1479].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1479].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[147].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[147].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1480].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1480].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1481].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1481].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1482].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1482].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1483].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1483].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1484].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1484].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1485].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1485].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1486].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1486].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1487].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1487].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1488].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1488].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1489].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1489].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[148].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[148].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1490].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1490].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1491].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1491].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1492].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1492].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1493].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1493].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1494].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1494].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1495].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1495].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1496].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1496].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1497].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1497].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1498].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1498].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1499].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1499].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[149].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[149].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[14].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[14].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1500].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1500].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1501].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1501].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1502].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1502].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1503].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1503].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1504].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1504].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1505].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1505].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1506].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1506].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1507].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1507].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1508].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1508].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1509].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1509].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[150].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[150].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1510].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1510].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1511].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1511].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1512].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1512].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1513].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1513].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1514].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1514].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1515].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1515].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1516].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1516].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1517].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1517].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1518].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1518].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1519].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1519].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[151].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[151].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1520].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1520].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1521].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1521].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1522].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1522].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1523].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1523].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1524].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1524].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1525].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1525].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1526].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1526].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1527].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1527].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1528].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1528].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1529].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1529].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[152].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[152].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1530].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1530].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1531].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1531].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1532].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1532].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1533].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1533].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1534].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1534].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1535].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1535].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1536].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1536].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1537].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1537].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1538].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1538].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1539].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1539].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[153].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[153].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1540].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1540].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1541].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1541].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1542].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1542].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1543].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1543].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1544].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1544].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1545].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1545].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1546].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1546].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1547].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1547].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1548].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1548].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1549].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1549].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[154].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[154].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1550].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1550].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1551].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1551].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1552].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1552].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1553].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1553].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1554].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1554].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1555].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1555].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1556].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1556].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1557].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1557].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1558].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1558].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1559].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1559].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[155].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[155].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1560].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1560].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1561].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1561].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1562].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1562].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1563].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1563].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1564].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1564].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1565].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1565].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1566].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1566].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1567].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1567].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1568].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1568].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1569].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1569].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[156].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[156].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1570].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1570].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1571].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1571].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1572].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1572].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1573].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1573].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1574].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1574].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1575].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1575].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1576].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1576].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1577].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1577].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1578].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1578].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1579].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1579].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[157].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[157].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1580].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1580].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1581].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1581].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1582].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1582].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1583].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1583].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1584].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1584].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1585].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1585].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1586].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1586].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1587].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1587].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1588].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1588].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1589].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1589].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[158].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[158].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1590].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1590].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1591].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1591].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1592].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1592].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1593].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1593].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1594].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1594].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1595].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1595].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1596].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1596].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1597].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1597].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1598].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1598].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1599].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1599].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[159].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[159].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[15].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[15].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1600].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1600].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1601].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1601].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1602].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1602].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1603].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1603].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1604].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1604].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1605].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1605].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1606].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1606].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1607].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1607].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1608].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1608].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1609].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1609].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[160].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[160].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1610].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1610].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1611].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1611].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1612].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1612].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1613].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1613].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1614].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1614].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1615].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1615].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1616].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1616].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1617].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1617].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1618].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1618].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1619].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1619].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[161].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[161].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1620].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1620].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1621].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1621].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1622].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1622].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1623].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1623].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1624].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1624].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1625].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1625].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1626].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1626].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1627].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1627].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1628].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1628].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1629].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1629].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[162].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[162].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1630].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1630].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1631].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1631].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1632].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1632].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1633].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1633].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1634].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1634].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1635].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1635].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1636].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1636].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1637].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1637].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1638].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1638].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1639].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1639].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[163].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[163].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1640].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1640].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1641].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1641].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1642].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1642].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1643].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1643].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1644].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1644].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1645].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1645].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1646].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1646].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1647].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1647].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1648].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1648].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1649].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1649].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[164].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[164].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1650].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1650].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1651].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1651].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1652].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1652].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1653].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1653].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1654].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1654].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1655].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1655].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1656].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1656].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1657].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1657].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1658].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1658].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1659].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1659].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[165].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[165].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1660].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1660].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1661].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1661].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1662].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1662].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1663].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1663].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1664].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1664].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1665].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1665].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1666].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1666].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1667].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1667].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1668].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1668].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1669].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1669].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[166].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[166].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1670].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1670].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1671].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1671].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1672].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1672].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1673].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1673].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1674].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1674].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1675].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1675].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1676].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1676].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1677].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1677].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1678].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1678].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1679].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1679].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[167].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[167].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1680].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1680].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1681].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1681].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1682].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1682].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1683].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1683].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1684].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1684].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1685].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1685].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1686].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1686].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1687].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1687].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1688].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1688].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1689].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1689].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[168].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[168].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1690].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1690].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1691].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1691].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1692].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1692].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1693].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1693].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1694].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1694].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1695].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1695].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1696].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1696].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1697].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1697].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1698].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1698].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1699].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1699].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[169].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[169].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[16].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[16].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1700].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1700].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1701].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1701].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1702].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1702].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1703].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1703].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1704].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1704].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1705].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1705].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1706].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1706].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1707].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1707].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1708].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1708].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1709].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1709].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[170].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[170].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1710].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1710].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1711].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1711].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1712].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1712].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1713].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1713].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1714].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1714].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1715].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1715].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1716].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1716].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1717].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1717].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1718].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1718].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1719].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1719].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[171].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[171].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1720].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1720].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1721].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1721].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1722].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1722].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1723].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1723].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1724].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1724].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1725].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1725].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1726].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1726].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1727].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1727].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1728].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1728].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1729].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1729].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[172].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[172].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1730].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1730].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1731].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1731].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1732].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1732].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1733].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1733].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1734].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1734].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1735].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1735].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1736].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1736].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1737].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1737].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1738].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1738].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1739].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1739].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[173].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[173].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1740].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1740].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1741].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1741].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1742].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1742].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1743].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1743].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1744].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1744].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1745].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1745].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1746].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1746].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1747].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1747].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1748].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1748].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1749].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1749].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[174].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[174].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1750].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1750].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1751].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1751].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1752].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1752].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1753].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1753].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1754].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1754].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1755].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1755].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1756].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1756].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1757].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1757].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1758].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1758].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1759].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1759].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[175].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[175].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1760].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1760].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1761].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1761].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1762].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1762].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1763].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1763].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1764].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1764].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1765].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1765].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1766].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1766].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1767].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1767].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1768].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1768].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1769].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1769].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[176].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[176].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1770].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1770].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1771].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1771].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1772].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1772].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1773].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1773].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1774].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1774].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1775].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1775].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1776].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1776].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1777].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1777].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1778].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1778].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1779].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1779].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[177].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[177].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1780].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1780].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1781].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1781].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1782].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1782].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1783].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1783].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1784].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1784].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1785].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1785].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1786].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1786].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1787].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1787].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1788].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1788].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1789].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1789].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[178].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[178].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1790].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1790].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1791].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1791].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1792].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1792].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1793].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1793].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1794].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1794].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1795].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1795].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1796].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1796].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1797].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1797].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1798].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1798].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1799].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1799].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[179].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[179].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[17].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[17].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1800].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1800].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1801].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1801].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1802].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1802].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1803].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1803].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1804].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1804].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1805].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1805].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1806].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1806].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1807].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1807].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1808].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1808].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1809].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1809].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[180].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[180].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1810].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1810].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1811].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1811].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[181].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[181].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[182].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[182].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[183].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[183].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[184].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[184].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[185].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[185].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[186].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[186].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[187].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[187].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[188].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[188].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[189].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[189].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[18].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[18].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[190].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[190].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[191].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[191].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[192].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[192].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[193].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[193].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[194].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[194].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[195].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[195].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[196].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[196].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[197].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[197].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[198].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[198].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[199].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[199].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[19].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[19].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[1].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[200].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[200].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[201].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[201].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[202].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[202].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[203].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[203].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[204].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[204].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[205].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[205].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[206].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[206].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[207].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[207].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[208].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[208].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[209].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[209].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[20].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[20].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[210].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[210].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[211].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[211].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[212].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[212].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[213].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[213].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[214].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[214].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[215].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[215].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[216].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[216].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[217].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[217].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[218].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[218].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[219].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[219].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[21].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[21].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[220].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[220].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[221].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[221].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[222].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[222].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[223].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[223].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[224].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[224].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[225].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[225].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[226].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[226].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[227].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[227].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[228].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[228].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[229].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[229].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[22].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[22].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[230].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[230].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[231].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[231].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[232].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[232].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[233].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[233].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[234].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[234].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[235].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[235].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[236].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[236].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[237].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[237].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[238].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[238].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[239].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[239].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[23].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[23].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[240].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[240].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[241].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[241].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[242].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[242].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[243].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[243].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[244].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[244].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[245].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[245].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[246].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[246].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[247].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[247].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[248].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[248].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[249].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[249].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[24].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[24].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[250].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[250].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[251].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[251].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[252].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[252].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[253].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[253].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[254].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[254].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[255].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[255].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[256].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[256].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[257].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[257].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[258].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[258].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[259].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[259].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[25].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[25].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[260].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[260].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[261].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[261].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[262].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[262].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[263].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[263].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[264].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[264].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[265].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[265].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[266].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[266].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[267].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[267].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[268].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[268].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[269].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[269].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[26].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[26].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[270].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[270].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[271].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[271].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[272].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[272].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[273].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[273].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[274].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[274].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[275].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[275].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[276].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[276].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[277].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[277].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[278].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[278].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[279].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[279].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[27].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[27].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[280].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[280].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[281].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[281].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[282].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[282].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[283].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[283].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[284].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[284].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[285].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[285].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[286].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[286].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[287].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[287].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[288].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[288].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[289].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[289].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[28].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[28].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[290].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[290].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[291].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[291].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[292].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[292].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[293].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[293].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[294].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[294].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[295].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[295].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[296].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[296].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[297].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[297].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[298].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[298].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[299].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[299].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[29].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[29].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[2].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[2].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[300].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[300].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[301].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[301].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[302].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[302].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[303].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[303].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[304].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[304].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[305].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[305].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[306].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[306].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[307].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[307].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[308].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[308].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[309].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[309].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[30].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[30].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[310].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[310].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[311].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[311].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[312].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[312].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[313].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[313].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[314].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[314].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[315].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[315].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[316].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[316].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[317].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[317].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[318].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[318].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[319].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[319].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[31].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[31].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[320].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[320].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[321].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[321].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[322].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[322].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[323].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[323].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[324].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[324].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[325].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[325].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[326].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[326].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[327].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[327].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[328].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[328].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[329].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[329].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[32].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[32].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[330].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[330].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[331].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[331].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[332].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[332].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[333].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[333].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[334].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[334].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[335].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[335].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[336].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[336].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[337].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[337].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[338].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[338].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[339].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[339].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[33].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[33].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[340].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[340].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[341].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[341].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[342].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[342].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[343].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[343].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[344].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[344].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[345].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[345].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[346].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[346].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[347].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[347].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[348].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[348].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[349].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[349].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[34].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[34].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[350].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[350].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[351].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[351].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[352].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[352].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[353].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[353].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[354].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[354].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[355].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[355].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[356].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[356].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[357].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[357].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[358].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[358].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[359].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[359].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[35].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[35].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[360].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[360].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[361].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[361].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[362].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[362].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[363].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[363].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[364].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[364].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[365].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[365].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[366].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[366].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[367].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[367].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[368].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[368].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[369].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[369].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[36].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[36].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[370].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[370].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[371].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[371].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[372].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[372].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[373].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[373].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[374].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[374].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[375].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[375].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[376].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[376].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[377].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[377].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[378].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[378].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[379].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[379].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[37].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[37].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[380].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[380].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[381].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[381].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[382].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[382].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[383].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[383].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[384].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[384].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[385].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[385].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[386].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[386].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[387].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[387].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[388].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[388].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[389].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[389].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[38].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[38].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[390].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[390].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[391].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[391].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[392].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[392].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[393].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[393].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[394].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[394].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[395].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[395].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[396].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[396].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[397].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[397].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[398].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[398].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[399].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[399].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[39].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[39].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[3].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[3].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[400].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[400].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[401].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[401].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[402].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[402].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[403].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[403].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[404].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[404].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[405].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[405].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[406].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[406].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[407].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[407].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[408].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[408].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[409].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[409].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[40].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[40].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[410].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[410].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[411].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[411].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[412].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[412].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[413].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[413].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[414].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[414].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[415].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[415].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[416].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[416].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[417].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[417].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[418].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[418].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[419].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[419].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[41].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[41].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[420].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[420].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[421].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[421].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[422].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[422].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[423].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[423].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[424].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[424].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[425].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[425].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[426].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[426].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[427].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[427].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[428].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[428].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[429].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[429].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[42].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[42].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[430].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[430].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[431].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[431].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[432].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[432].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[433].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[433].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[434].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[434].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[435].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[435].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[436].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[436].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[437].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[437].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[438].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[438].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[439].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[439].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[43].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[43].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[440].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[440].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[441].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[441].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[442].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[442].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[443].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[443].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[444].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[444].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[445].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[445].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[446].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[446].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[447].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[447].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[448].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[448].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[449].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[449].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[44].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[44].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[450].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[450].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[451].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[451].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[452].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[452].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[453].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[453].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[454].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[454].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[455].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[455].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[456].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[456].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[457].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[457].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[458].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[458].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[459].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[459].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[45].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[45].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[460].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[460].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[461].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[461].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[462].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[462].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[463].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[463].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[464].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[464].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[465].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[465].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[466].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[466].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[467].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[467].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[468].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[468].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[469].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[469].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[46].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[46].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[470].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[470].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[471].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[471].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[472].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[472].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[473].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[473].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[474].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[474].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[475].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[475].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[476].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[476].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[477].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[477].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[478].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[478].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[479].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[479].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[47].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[47].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[480].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[480].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[481].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[481].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[482].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[482].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[483].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[483].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[484].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[484].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[485].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[485].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[486].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[486].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[487].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[487].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[488].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[488].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[489].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[489].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[48].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[48].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[490].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[490].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[491].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[491].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[492].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[492].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[493].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[493].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[494].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[494].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[495].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[495].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[496].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[496].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[497].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[497].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[498].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[498].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[499].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[499].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[49].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[49].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[4].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[4].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[500].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[500].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[501].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[501].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[502].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[502].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[503].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[503].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[504].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[504].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[505].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[505].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[506].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[506].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[507].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[507].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[508].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[508].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[509].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[509].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[50].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[50].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[510].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[510].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[511].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[511].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[512].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[512].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[513].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[513].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[514].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[514].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[515].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[515].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[516].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[516].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[517].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[517].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[518].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[518].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[519].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[519].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[51].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[51].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[520].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[520].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[521].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[521].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[522].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[522].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[523].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[523].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[524].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[524].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[525].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[525].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[526].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[526].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[527].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[527].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[528].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[528].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[529].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[529].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[52].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[52].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[530].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[530].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[531].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[531].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[532].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[532].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[533].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[533].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[534].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[534].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[535].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[535].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[536].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[536].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[537].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[537].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[538].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[538].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[539].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[539].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[53].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[53].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[540].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[540].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[541].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[541].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[542].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[542].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[543].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[543].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[544].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[544].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[545].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[545].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[546].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[546].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[547].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[547].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[548].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[548].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[549].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[549].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[54].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[54].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[550].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[550].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[551].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[551].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[552].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[552].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[553].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[553].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[554].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[554].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[555].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[555].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[556].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[556].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[557].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[557].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[558].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[558].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[559].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[559].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[55].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[55].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[560].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[560].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[561].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[561].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[562].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[562].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[563].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[563].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[564].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[564].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[565].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[565].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[566].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[566].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[567].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[567].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[568].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[568].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[569].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[569].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[56].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[56].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[570].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[570].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[571].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[571].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[572].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[572].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[573].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[573].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[574].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[574].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[575].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[575].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[576].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[576].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[577].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[577].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[578].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[578].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[579].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[579].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[57].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[57].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[580].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[580].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[581].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[581].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[582].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[582].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[583].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[583].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[584].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[584].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[585].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[585].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[586].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[586].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[587].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[587].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[588].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[588].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[589].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[589].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[58].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[58].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[590].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[590].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[591].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[591].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[592].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[592].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[593].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[593].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[594].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[594].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[595].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[595].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[596].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[596].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[597].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[597].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[598].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[598].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[599].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[599].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[59].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[59].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[5].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[5].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[600].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[600].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[601].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[601].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[602].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[602].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[603].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[603].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[604].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[604].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[605].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[605].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[606].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[606].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[607].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[607].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[608].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[608].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[609].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[609].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[60].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[60].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[610].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[610].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[611].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[611].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[612].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[612].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[613].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[613].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[614].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[614].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[615].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[615].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[616].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[616].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[617].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[617].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[618].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[618].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[619].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[619].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[61].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[61].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[620].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[620].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[621].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[621].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[622].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[622].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[623].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[623].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[624].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[624].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[625].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[625].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[626].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[626].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[627].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[627].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[628].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[628].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[629].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[629].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[62].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[62].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[630].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[630].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[631].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[631].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[632].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[632].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[633].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[633].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[634].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[634].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[635].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[635].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[636].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[636].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[637].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[637].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[638].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[638].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[639].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[639].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[63].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[63].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[640].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[640].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[641].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[641].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[642].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[642].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[643].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[643].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[644].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[644].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[645].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[645].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[646].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[646].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[647].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[647].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[648].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[648].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[649].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[649].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[64].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[64].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[650].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[650].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[651].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[651].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[652].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[652].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[653].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[653].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[654].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[654].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[655].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[655].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[656].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[656].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[657].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[657].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[658].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[658].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[659].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[659].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[65].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[65].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[660].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[660].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[661].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[661].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[662].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[662].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[663].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[663].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[664].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[664].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[665].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[665].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[666].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[666].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[667].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[667].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[668].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[668].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[669].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[669].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[66].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[66].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[670].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[670].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[671].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[671].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[672].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[672].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[673].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[673].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[674].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[674].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[675].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[675].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[676].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[676].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[677].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[677].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[678].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[678].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[679].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[679].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[67].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[67].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[680].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[680].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[681].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[681].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[682].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[682].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[683].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[683].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[684].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[684].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[685].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[685].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[686].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[686].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[687].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[687].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[688].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[688].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[689].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[689].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[68].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[68].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[690].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[690].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[691].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[691].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[692].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[692].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[693].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[693].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[694].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[694].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[695].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[695].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[696].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[696].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[697].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[697].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[698].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[698].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[699].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[699].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[69].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[69].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[6].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[6].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[700].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[700].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[701].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[701].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[702].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[702].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[703].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[703].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[704].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[704].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[705].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[705].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[706].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[706].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[707].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[707].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[708].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[708].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[709].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[709].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[70].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[70].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[710].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[710].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[711].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[711].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[712].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[712].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[713].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[713].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[714].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[714].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[715].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[715].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[716].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[716].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[717].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[717].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[718].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[718].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[719].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[719].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[71].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[71].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[720].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[720].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[721].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[721].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[722].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[722].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[723].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[723].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[724].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[724].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[725].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[725].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[726].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[726].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[727].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[727].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[728].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[728].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[729].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[729].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[72].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[72].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[730].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[730].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[731].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[731].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[732].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[732].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[733].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[733].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[734].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[734].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[735].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[735].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[736].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[736].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[737].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[737].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[738].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[738].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[739].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[739].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[73].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[73].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[740].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[740].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[741].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[741].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[742].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[742].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[743].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[743].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[744].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[744].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[745].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[745].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[746].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[746].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[747].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[747].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[748].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[748].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[749].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[749].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[74].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[74].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[750].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[750].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[751].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[751].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[752].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[752].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[753].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[753].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[754].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[754].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[755].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[755].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[756].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[756].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[757].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[757].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[758].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[758].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[759].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[759].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[75].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[75].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[760].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[760].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[761].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[761].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[762].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[762].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[763].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[763].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[764].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[764].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[765].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[765].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[766].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[766].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[767].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[767].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[768].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[768].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[769].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[769].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[76].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[76].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[770].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[770].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[771].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[771].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[772].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[772].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[773].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[773].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[774].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[774].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[775].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[775].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[776].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[776].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[777].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[777].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[778].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[778].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[779].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[779].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[77].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[77].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[780].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[780].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[781].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[781].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[782].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[782].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[783].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[783].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[784].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[784].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[785].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[785].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[786].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[786].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[787].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[787].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[788].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[788].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[789].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[789].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[78].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[78].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[790].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[790].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[791].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[791].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[792].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[792].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[793].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[793].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[794].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[794].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[795].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[795].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[796].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[796].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[797].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[797].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[798].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[798].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[799].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[799].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[79].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[79].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[7].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[7].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[800].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[800].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[801].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[801].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[802].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[802].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[803].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[803].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[804].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[804].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[805].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[805].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[806].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[806].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[807].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[807].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[808].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[808].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[809].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[809].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[80].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[80].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[810].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[810].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[811].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[811].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[812].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[812].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[813].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[813].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[814].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[814].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[815].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[815].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[816].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[816].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[817].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[817].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[818].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[818].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[819].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[819].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[81].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[81].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[820].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[820].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[821].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[821].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[822].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[822].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[823].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[823].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[824].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[824].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[825].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[825].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[826].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[826].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[827].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[827].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[828].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[828].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[829].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[829].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[82].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[82].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[830].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[830].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[831].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[831].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[832].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[832].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[833].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[833].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[834].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[834].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[835].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[835].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[836].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[836].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[837].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[837].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[838].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[838].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[839].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[839].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[83].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[83].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[840].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[840].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[841].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[841].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[842].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[842].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[843].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[843].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[844].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[844].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[845].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[845].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[846].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[846].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[847].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[847].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[848].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[848].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[849].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[849].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[84].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[84].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[850].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[850].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[851].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[851].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[852].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[852].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[853].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[853].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[854].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[854].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[855].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[855].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[856].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[856].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[857].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[857].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[858].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[858].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[859].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[859].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[85].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[85].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[860].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[860].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[861].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[861].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[862].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[862].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[863].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[863].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[864].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[864].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[865].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[865].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[866].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[866].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[867].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[867].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[868].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[868].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[869].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[869].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[86].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[86].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[870].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[870].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[871].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[871].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[872].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[872].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[873].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[873].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[874].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[874].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[875].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[875].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[876].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[876].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[877].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[877].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[878].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[878].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[879].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[879].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[87].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[87].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[880].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[880].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[881].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[881].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[882].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[882].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[883].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[883].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[884].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[884].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[885].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[885].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[886].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[886].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[887].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[887].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[888].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[888].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[889].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[889].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[88].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[88].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[890].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[890].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[891].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[891].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[892].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[892].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[893].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[893].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[894].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[894].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[895].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[895].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[896].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[896].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[897].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[897].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[898].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[898].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[899].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[899].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[89].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[89].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[8].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[8].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[900].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[900].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[901].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[901].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[902].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[902].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[903].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[903].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[904].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[904].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[905].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[905].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[906].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[906].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[907].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[907].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[908].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[908].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[909].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[909].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[90].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[90].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[910].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[910].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[911].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[911].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[912].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[912].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[913].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[913].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[914].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[914].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[915].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[915].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[916].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[916].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[917].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[917].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[918].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[918].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[919].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[919].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[91].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[91].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[920].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[920].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[921].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[921].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[922].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[922].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[923].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[923].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[924].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[924].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[925].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[925].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[926].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[926].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[927].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[927].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[928].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[928].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[929].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[929].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[92].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[92].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[930].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[930].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[931].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[931].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[932].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[932].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[933].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[933].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[934].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[934].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[935].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[935].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[936].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[936].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[937].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[937].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[938].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[938].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[939].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[939].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[93].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[93].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[940].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[940].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[941].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[941].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[942].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[942].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[943].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[943].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[944].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[944].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[945].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[945].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[946].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[946].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[947].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[947].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[948].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[948].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[949].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[949].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[94].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[94].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[950].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[950].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[951].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[951].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[952].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[952].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[953].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[953].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[954].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[954].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[955].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[955].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[956].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[956].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[957].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[957].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[958].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[958].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[959].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[959].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[95].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[95].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[960].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[960].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[961].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[961].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[962].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[962].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[963].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[963].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[964].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[964].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[965].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[965].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[966].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[966].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[967].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[967].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[968].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[968].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[969].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[969].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[96].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[96].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[970].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[970].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[971].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[971].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[972].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[972].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[973].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[973].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[974].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[974].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[975].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[975].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[976].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[976].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[977].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[977].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[978].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[978].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[979].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[979].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[97].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[97].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[980].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[980].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[981].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[981].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[982].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[982].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[983].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[983].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[984].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[984].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[985].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[985].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[986].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[986].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[987].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[987].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[988].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[988].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[989].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[989].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[98].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[98].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[990].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[990].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[991].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[991].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[992].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[992].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[993].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[993].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[994].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[994].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[995].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[995].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[996].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[996].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[997].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[997].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[998].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[998].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[999].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[999].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[99].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[99].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[9].u0_DCDC_CAP_UNIT y0_bot[5] y0_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_cap[9].u1_DCDC_CAP_UNIT y1_bot[5] y1_top[5] DCDC_CAP_UNIT
Xgen_stage[5].gen_conv[0].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[100].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[101].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[102].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[103].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[104].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[105].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[106].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[107].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[108].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[109].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[10].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[110].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[111].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[112].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[113].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[114].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[115].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[116].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[117].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[118].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[119].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[11].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[120].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[121].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[122].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[123].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[124].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[125].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[126].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[127].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[128].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[129].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[12].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[130].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[131].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[132].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[133].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[134].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[135].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[136].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[137].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[138].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[139].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[13].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[140].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[141].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[142].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[143].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[144].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[145].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[146].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[147].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[148].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[149].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[14].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[150].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[151].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[152].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[153].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[154].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[155].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[156].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[157].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[158].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[159].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[15].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[160].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[161].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[162].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[163].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[164].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[165].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[166].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[167].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[168].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[169].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[16].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[170].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[171].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[172].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[173].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[174].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[175].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[176].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[177].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[178].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[179].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[17].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[180].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[181].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[182].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[183].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[184].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[185].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[186].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[187].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[188].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[189].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[18].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[190].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[191].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[192].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[193].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[194].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[195].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[196].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[197].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[198].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[199].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[19].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[1].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[200].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[201].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[202].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[203].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[204].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[205].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[206].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[207].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[208].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[209].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[20].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[210].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[211].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[212].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[213].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[214].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[215].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[216].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[217].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[218].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[219].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[21].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[220].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[221].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[222].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[223].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[224].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[225].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[226].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[227].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[228].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[229].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[22].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[230].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[231].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[232].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[233].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[234].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[235].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[236].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[237].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[238].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[239].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[23].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[240].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[241].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[242].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[243].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[244].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[245].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[246].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[247].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[248].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[249].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[24].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[250].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[251].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[252].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[253].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[254].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[255].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[256].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[257].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[258].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[259].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[25].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[260].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[261].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[262].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[263].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[264].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[265].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[266].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[267].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[268].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[269].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[26].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[270].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[271].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[272].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[273].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[27].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[28].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[29].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[2].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[30].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[31].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[32].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[33].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[34].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[35].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[36].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[37].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[38].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[39].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[3].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[40].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[41].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[42].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[43].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[44].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[45].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[46].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[47].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[48].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[49].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[4].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[50].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[51].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[52].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[53].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[54].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[55].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[56].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[57].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[58].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[59].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[5].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[60].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[61].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[62].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[63].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[64].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[65].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[66].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[67].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[68].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[69].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[6].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[70].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[71].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[72].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[73].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[74].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[75].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[76].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[77].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[78].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[79].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[7].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[80].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[81].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[82].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[83].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[84].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[85].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[86].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[87].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[88].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[89].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[8].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[90].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[91].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[92].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[93].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[94].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[95].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[96].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[97].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[98].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[99].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].gen_conv[9].u_DCDC_CONV2TO1 VGND VPWR clk0 clk0b clk1
+ clk1b y0_top[5] y1_top[5] y0_bot[5] y1_bot[5]
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh VOUT
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_CONV2TO1
Xgen_stage[5].genblk1.u_DCDC_POWMUX.gen_powmux[0].powmux VGND VPWR SEL_H[5]
+ SEL_L[5] gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_MUX
Xgen_stage[5].genblk1.u_DCDC_POWMUX.gen_powmux[1].powmux VGND VPWR SEL_H[5]
+ SEL_L[5] gen_stage[5].genblk1.u_DCDC_POWMUX.vin
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vhigh
+ gen_stage[5].genblk1.u_DCDC_POWMUX.vlow DCDC_MUX
.ENDS

.GLOBAL VPWR
.GLOBAL VGND

* 2:1 stage: PMOS SWITCH
.subckt DCDC_XSW_PMOS VPB clk clkb vIN vOUT0 vOUT1
x0 int_sw0 int_sw1 vIN VPB sky130_fd_pr__pfet_01v8 w=420000u l=150000u
x1 int_sw1 int_sw0 vIN VPB sky130_fd_pr__pfet_01v8 w=420000u l=150000u
x2 vOUT0 int_sw0 vIN VPB sky130_fd_pr__pfet_01v8 w=1260000u l=150000u
x3 vOUT1 int_sw1 vIN VPB sky130_fd_pr__pfet_01v8 w=1260000u l=150000u
x4 clkb int_sw0 clkb clkb sky130_fd_pr__pfet_01v8 w=2100000u l=2100000u
x5 clk int_sw1 clk clk sky130_fd_pr__pfet_01v8 w=2100000u l=2100000u
.ends DCDC_XSW_PMOS

* 2:1 stage: NMOS SWITCH
.subckt DCDC_XSW_NMOS VNB clk clkb vIN vOUT0 vOUT1
x0 int_sw0 int_sw1 vIN VNB sky130_fd_pr__nfet_01v8 w=420000u l=150000u
x1 int_sw1 int_sw0 vIN VNB sky130_fd_pr__nfet_01v8 w=420000u l=150000u
x2 vOUT0 int_sw0 vIN VNB sky130_fd_pr__nfet_01v8 w=840000u l=150000u
x3 vOUT1 int_sw1 vIN VNB sky130_fd_pr__nfet_01v8 w=840000u l=150000u
x4 clkb int_sw0 clkb clkb sky130_fd_pr__pfet_01v8 w=2100000u l=2100000u
x5 clk int_sw1 clk clk sky130_fd_pr__pfet_01v8 w=2100000u l=2100000u
.ends DCDC_XSW_NMOS

*2:1 converter: DCDC_HUNIT_CONV2to1
.subckt DCDC_HUNIT_CONV2to1 VGND VPWR clk0 clk0b clk1 clk1b y0 y1 vhigh vlow
x0 VPWR clk1b clk0b vhigh y0 y1 DCDC_XSW_PMOS
x1 VGND clk0 clk1 vlow y0 y1 DCDC_XSW_NMOS
.ends DCDC_HUNIT_CONV2to1

*2:1 converter: DCDC_CONV2TO1
.subckt DCDC_CONV2TO1 VGND VPWR CLK0 CLK0B CLK1 CLK1B Y0_TOP Y1_TOP Y0_BOT Y1_BOT VHIGH VMID VLOW
x0 VGND VPWR CLK0 CLK0B CLK1 CLK1B Y0_TOP Y1_TOP VHIGH VMID DCDC_HUNIT_CONV2to1
x1 VGND VPWR CLK0 CLK0B CLK1 CLK1B Y0_BOT Y1_BOT VMID VLOW DCDC_HUNIT_CONV2TO1
.ends DCDC_CONV2TO1

* 2:1 stage: unit cap
.subckt DCDC_CAP_UNIT BOT TOP
x0 BOT TOP sky130_fd_pr__cap_mim_m3_1 w=7 l=19
.ends DCDC_CAP_UNIT

* power mux: DCDC_MUX
.subckt DCDC_MUX_PMOS VPWR SEL SEL_INV VIN VOUT
x1  VIN SEL_INV VOUT VPWR sky130_fd_pr__pfet_01v8 w=2100000u l=150000u m=3
x2  VOUT SEL     VIN VPWR sky130_fd_pr__pfet_01v8 w=2100000u l=150000u m=3
.ends DCDC_MUX_PMOS

.subckt DCDC_MUX_NMOS VGND SEL SEL_INV VIN VOUT
x1  VIN SEL_INV VOUT VGND sky130_fd_pr__nfet_01v8 w=2100000u l=150000u m=3
x2  VOUT SEL     VIN VGND sky130_fd_pr__nfet_01v8 w=2100000u l=150000u m=3
.ends DCDC_MUX_NMOS

.subckt DCDC_MUX_TGATE VGND VPWR SEL SEL_INV VIN VOUT
x1  VOUT SEL_INV VIN VPWR sky130_fd_pr__pfet_01v8 w=2100000u l=150000u m=3
x2  VOUT SEL     VIN VGND sky130_fd_pr__nfet_01v8 w=2100000u l=150000u m=3
.ends DCDC_MUX_TGATE

.subckt inv_4 A VGND VNB VPB VPWR Y
x1 Y A VGND VNB sky130_fd_pr__nfet_01v8 w=2100000u l=150000u
x2 Y A VPWR VPB sky130_fd_pr__pfet_01v8 w=2100000u l=150000u m=2
.ends inv_4

.subckt DCDC_MUX VGND VPWR SEL_H SEL_L VIN VOUT_H VOUT_L
x0 SEL_H VGND VGND VPWR VPWR SEL_INV_H inv_4
x1 SEL_L VGND VGND VPWR VPWR SEL_INV_L inv_4
* Top MUX rail
x2 VPWR SEL_INV_H SEL_INV_H VPWR VOUT_H DCDC_MUX_PMOS
* Top MUX mid
x3 VGND VPWR SEL_INV_H SEL_H VIN VOUT_H DCDC_MUX_TGATE
* Bot MUX mid
x4 VGND VPWR SEL_L SEL_INV_L VIN VOUT_L DCDC_MUX_TGATE
* Bot MUX rail
x5 VGND SEL_INV_L SEL_INV_L VGND VOUT_L DCDC_MUX_NMOS
.ends DCDC_MUX
