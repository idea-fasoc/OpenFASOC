* NGSPICE file created from diff_test.ext - technology: sky130A

.subckt diff_test
X0 a_n549_n997# a_n579_n1047# a_n674_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=0.75 ps=3.5 w=3 l=0.15
X1 a_n674_n997# a_n579_201# a_n549_397# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=0.75 ps=3.5 w=3 l=0.15
X2 a_n1366_n1488# a_n1366_n1488# a_n1366_n1488# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=1.425 pd=6.95 as=11.4 ps=55.6 w=3 l=0.15
X3 a_n549_397# a_n579_201# a_n674_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=1.425 ps=6.95 w=3 l=0.15
X4 a_n674_n997# a_n579_n1047# a_n549_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=1.425 pd=6.95 as=0.75 ps=3.5 w=3 l=0.15
X5 a_n1366_n1488# a_n1366_n1488# a_n1366_n1488# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=1.425 pd=6.95 as=0 ps=0 w=3 l=0.15
X6 a_n674_n997# a_n579_n1047# a_n549_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=0.75 ps=3.5 w=3 l=0.15
X7 a_n674_n997# a_n579_201# a_n549_397# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=1.425 pd=6.95 as=0.75 ps=3.5 w=3 l=0.15
X8 a_n549_n997# a_n579_n1047# a_n674_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=1.425 ps=6.95 w=3 l=0.15
X9 a_n674_n997# a_n579_n1047# a_n549_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=1.425 pd=6.95 as=0.75 ps=3.5 w=3 l=0.15
X10 a_n549_397# a_n579_201# a_n674_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=0.75 ps=3.5 w=3 l=0.15
X11 a_n674_n997# a_n579_201# a_n549_397# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=1.425 pd=6.95 as=0.75 ps=3.5 w=3 l=0.15
X12 a_n549_n997# a_n579_n1047# a_n674_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=0.75 ps=3.5 w=3 l=0.15
X13 a_n549_397# a_n579_201# a_n674_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=1.425 ps=6.95 w=3 l=0.15
X14 a_n549_n997# a_n579_n1047# a_n674_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=1.425 ps=6.95 w=3 l=0.15
X15 a_n1366_n1488# a_n1366_n1488# a_n1366_n1488# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=1.425 pd=6.95 as=0 ps=0 w=3 l=0.15
X16 a_n1366_n1488# a_n1366_n1488# a_n1366_n1488# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=1.425 pd=6.95 as=0 ps=0 w=3 l=0.15
X17 a_n674_n997# a_n579_201# a_n549_397# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=0.75 ps=3.5 w=3 l=0.15
X18 a_n549_397# a_n579_201# a_n674_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=0.75 ps=3.5 w=3 l=0.15
X19 a_n674_n997# a_n579_n1047# a_n549_n997# a_n1366_n1488# sky130_fd_pr__nfet_01v8 ad=0.75 pd=3.5 as=0.75 ps=3.5 w=3 l=0.15
C0 a_n579_201# a_n579_n1047# 3.16374f
C1 a_n549_n997# a_n674_n997# 5.61466f
C2 a_n549_397# a_n674_n997# 5.57563f
C3 a_n549_n997# a_n549_397# 0.641247f
C4 a_n674_n997# a_n579_n1047# 0.751816f
C5 a_n549_n997# a_n579_n1047# 0.803013f
C6 a_n579_201# a_n674_n997# 0.765855f
C7 a_n549_n997# a_n579_201# 0.287679f
C8 a_n549_397# a_n579_n1047# 0.157927f
C9 a_n579_201# a_n549_397# 0.932267f
C10 a_n549_n997# a_n1366_n1488# 2.02549f
C11 a_n549_397# a_n1366_n1488# 2.19698f
C12 a_n674_n997# a_n1366_n1488# 3.42969f
C13 a_n579_n1047# a_n1366_n1488# 4.21568f
C14 a_n579_201# a_n1366_n1488# 4.0956f
.ends
