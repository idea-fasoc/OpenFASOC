* NGSPICE file created from opamp_test.ext - technology: sky130A

.subckt opamp_test
X0 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=2.73 ps=14.78 w=7 l=1
X1 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X2 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X3 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=216.36 ps=1.2408k w=7 l=1
X4 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X5 a_n2511_10156# a_n2686_12378# a_n2686_12378# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X6 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X7 a_n2686_8022# a_n2686_12378# a_n7677_7899# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X8 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=2
X9 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X10 a_n7677_7899# a_n1140_1442# a_n1455_n3628# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X11 w_n8526_7510# a_n7935_n484# a_12876_1294# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X12 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X13 a_n2686_12378# a_n2686_12378# a_n2511_10156# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X14 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X15 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X16 a_n9311_n3159# a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X17 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X18 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X19 a_n2686_12378# a_n2148_3925# a_n1455_n3628# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X20 a_n7935_n484# a_n2686_8022# sky130_fd_pr__cap_mim_m3_1 l=12 w=12
X21 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X22 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X23 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X24 a_n1455_n3628# a_n2517_n3844# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X25 a_n1455_n3628# a_n2148_3925# a_n2686_12378# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X26 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X27 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X28 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X29 a_n2686_8022# a_n2686_12378# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X30 a_n2517_n3844# a_n2517_n3844# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X31 a_n1140_1442# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.5
X32 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=204.66 ps=1.15624k w=6 l=2
X33 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=1.155 ps=7.33 w=7 l=1
X34 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=2.73 ps=14.78 w=7 l=1
X35 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X36 a_n9311_n3159# a_n9311_n3159# a_n2148_3925# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.39 pd=2.78 as=0.165 ps=1.33 w=1 l=0.5
X37 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X38 a_n9311_n3159# a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=2
X39 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=2
X40 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X41 a_12876_1294# a_n7935_n484# w_n8526_7510# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X42 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X43 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X44 a_n2686_8022# a_n2686_12378# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X45 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X46 a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=2
X47 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X48 a_n2517_n3844# a_n2517_n3844# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X49 a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=2
X50 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X51 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X52 a_12876_1294# a_n7935_n484# w_n8526_7510# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=1.95 pd=10.78 as=0.825 ps=5.33 w=5 l=1
X53 a_n1455_n3628# a_n2148_3925# a_n2686_12378# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X54 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X55 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X56 a_n9311_n3159# a_n9311_n3159# a_n2148_3925# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.33 as=0.39 ps=2.78 w=1 l=0.5
X57 a_12876_1294# a_13154_n1884# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X58 a_n9311_n3159# a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=2
X59 a_n2686_12378# a_n2686_12378# a_n2511_10156# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X60 a_n1455_n3628# a_n2517_n3844# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X61 a_n2686_12378# a_n2686_12378# a_n2511_10156# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X62 a_n7677_7899# a_n1140_1442# a_n1455_n3628# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X63 a_n9311_n3159# a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X64 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X65 a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X66 w_n8526_7510# a_n7935_n484# a_12876_1294# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=1.95 ps=10.78 w=5 l=1
X67 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X68 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=1.155 ps=7.33 w=7 l=1
X69 a_n1140_1442# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.5
X70 a_n2686_8022# a_n2686_12378# a_n7677_7899# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X71 a_n9311_n3159# a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X72 a_n2686_8022# a_n2686_12378# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X73 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X74 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X75 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=1.155 ps=7.33 w=7 l=1
X76 a_n7935_n484# a_n2686_8022# sky130_fd_pr__cap_mim_m3_1 l=12 w=12
X77 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X78 a_n1455_n3628# a_n1140_1442# a_n7677_7899# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X79 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X80 a_n2511_10156# a_n2686_12378# a_n2686_12378# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X81 a_n7677_7899# a_n2686_12378# a_n2686_8022# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X82 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X83 a_n7935_n484# a_n2686_8022# sky130_fd_pr__cap_mim_m3_1 l=12 w=12
X84 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X85 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X86 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X87 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=2
X88 a_n9311_n3159# a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X89 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X90 a_n7935_n484# a_n2686_8022# sky130_fd_pr__cap_mim_m3_1 l=12 w=12
X91 a_12876_1294# a_n7935_n484# w_n8526_7510# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X92 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X93 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X94 a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X95 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X96 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X97 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X98 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X99 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X100 a_n7677_7899# a_n2686_12378# a_n2686_8022# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X101 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X102 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X103 w_n8526_7510# a_n2686_12378# a_n2511_10156# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X104 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X105 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=2.73 ps=14.78 w=7 l=1
X106 a_n2686_8022# a_n2686_12378# a_n7677_7899# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X107 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X108 a_n2511_10156# a_n2686_12378# a_n2686_12378# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X109 a_n9311_n3159# a_n9311_n3159# a_n1140_1442# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.39 pd=2.78 as=0.165 ps=1.33 w=1 l=0.5
X110 w_n8526_7510# a_n7935_n484# a_12876_1294# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X111 a_n7677_7899# a_n1140_1442# a_n1455_n3628# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X112 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X113 a_n2148_3925# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.5
X114 a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X115 w_n8526_7510# a_n2686_12378# a_n2511_10156# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X116 w_n8526_7510# a_n2686_12378# a_n2686_8022# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X117 a_n7677_7899# a_n2686_12378# a_n2686_8022# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X118 a_13154_n1884# a_13154_n1884# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X119 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=2
X120 a_n2517_n3844# a_n2517_n3844# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X121 a_13154_n1884# a_13154_n1884# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X122 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=2.73 ps=14.78 w=7 l=1
X123 a_n2686_8022# a_n2686_12378# a_n7677_7899# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X124 a_13154_n1884# a_13154_n1884# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X125 w_n8526_7510# a_n2686_12378# a_n2686_8022# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X126 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X127 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X128 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X129 a_n2686_8022# a_n2686_12378# a_n7677_7899# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X130 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X131 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X132 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X133 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=2
X134 w_n8526_7510# a_n2686_12378# a_n2511_10156# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X135 a_n2511_10156# a_n2686_12378# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X136 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X137 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X138 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X139 a_n1455_n3628# a_n2148_3925# a_n2686_12378# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X140 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X141 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X142 a_n9311_n3159# a_n9311_n3159# a_n1140_1442# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.5
X143 a_n1455_n3628# a_n2517_n3844# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X144 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X145 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X146 a_n7677_7899# a_n2686_12378# a_n2686_8022# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X147 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X148 a_13154_n1884# a_13154_n1884# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X149 a_n2686_12378# a_n2148_3925# a_n1455_n3628# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X150 w_n8526_7510# a_n7935_n484# a_12876_1294# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X151 a_n1455_n3628# a_n1140_1442# a_n7677_7899# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X152 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X153 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=1.155 ps=7.33 w=7 l=1
X154 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X155 a_n2511_10156# a_n2686_12378# a_n2686_12378# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X156 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X157 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X158 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X159 a_n2686_12378# a_n2686_12378# a_n2511_10156# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X160 w_n8526_7510# a_n2686_12378# a_n2686_8022# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X161 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=2
X162 a_n7677_7899# a_n1140_1442# a_n1455_n3628# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X163 a_n2686_12378# a_n2148_3925# a_n1455_n3628# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X164 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X165 a_n1455_n3628# a_n1140_1442# a_n7677_7899# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X166 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X167 a_n2686_12378# a_n2686_12378# a_n2511_10156# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X168 a_n7677_7899# a_n2686_12378# a_n2686_8022# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X169 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X170 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X171 a_n2686_8022# a_n2686_12378# a_n7677_7899# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X172 a_12876_1294# a_n7935_n484# w_n8526_7510# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X173 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X174 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X175 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X176 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X177 a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X178 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=2
X179 a_n1455_n3628# a_n2148_3925# a_n2686_12378# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X180 w_n8526_7510# a_n2686_12378# a_n2686_8022# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X181 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X182 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X183 a_n2511_10156# a_n2686_12378# a_n2686_12378# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X184 a_n1455_n3628# a_n2517_n3844# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X185 a_n2686_8022# a_n2686_12378# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X186 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X187 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=1.155 ps=7.33 w=7 l=1
X188 a_n2511_10156# a_n2686_12378# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X189 a_n7935_n484# a_n2686_8022# sky130_fd_pr__cap_mim_m3_1 l=12 w=12
X190 a_n9311_n3159# a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X191 w_n8526_7510# a_n7935_n484# a_12876_1294# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X192 a_12876_1294# a_n7935_n484# w_n8526_7510# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X193 a_n2511_10156# a_n2686_12378# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0.99 ps=6.33 w=6 l=1
X194 a_n7677_7899# a_n2686_12378# a_n2686_8022# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X195 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X196 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X197 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X198 a_12876_1294# a_n7935_n484# w_n8526_7510# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X199 a_n9311_n3159# a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X200 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X201 a_n2148_3925# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.5
X202 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X203 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X204 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X205 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X206 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X207 a_n2686_12378# a_n2686_12378# a_n2511_10156# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X208 a_n2517_n3844# a_n2517_n3844# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X209 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X210 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X211 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X212 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=2
X213 w_n8526_7510# a_n2686_12378# a_n2511_10156# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X214 a_n7935_n484# a_n2686_8022# sky130_fd_pr__cap_mim_m3_1 l=12 w=12
X215 a_12876_1294# a_13154_n1884# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X216 a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X217 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X218 a_12876_1294# a_n7935_n484# w_n8526_7510# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X219 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X220 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X221 a_12876_1294# a_13154_n1884# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X222 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X223 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X224 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=1.95 pd=10.78 as=0 ps=0 w=5 l=1
X225 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=1.95 pd=10.78 as=0 ps=0 w=5 l=1
X226 a_n2511_10156# a_n2686_12378# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X227 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=1.155 ps=7.33 w=7 l=1
X228 a_12876_1294# a_13154_n1884# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=2.34 ps=12.78 w=6 l=2
X229 w_n8526_7510# a_n7935_n484# a_12876_1294# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X230 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X231 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=2.73 ps=14.78 w=7 l=1
X232 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X233 a_n7935_n484# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X234 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X235 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X236 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X237 w_n8526_7510# a_n7677_7899# a_n7935_n484# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X238 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
X239 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X240 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X241 a_n9311_n3159# a_n9311_n3159# a_n1140_1442# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.33 as=0.39 ps=2.78 w=1 l=0.5
X242 a_n9311_n3159# a_n8335_n2966# a_n7935_n484# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X243 w_n8526_7510# a_n7935_n484# a_12876_1294# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X244 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.73 pd=14.78 as=0 ps=0 w=7 l=1
X245 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=1.155 ps=7.33 w=7 l=1
X246 a_n2511_10156# a_n2686_12378# a_n2686_12378# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=0.99 pd=6.33 as=2.34 ps=12.78 w=6 l=1
X247 a_n1455_n3628# a_n1140_1442# a_n7677_7899# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X248 w_n8526_7510# w_n8526_7510# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=1
X249 a_n2686_12378# a_n2148_3925# a_n1455_n3628# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=1
X250 a_n8335_n2966# a_n8335_n2966# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.99 pd=6.33 as=0.99 ps=6.33 w=6 l=2
X251 w_n8526_7510# a_n7935_n484# a_12876_1294# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X252 a_12876_1294# a_n7935_n484# w_n8526_7510# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.825 pd=5.33 as=0.825 ps=5.33 w=5 l=1
X253 a_n7935_n484# a_n7677_7899# w_n8526_7510# w_n8526_7510# sky130_fd_pr__pfet_01v8 ad=1.155 pd=7.33 as=2.73 ps=14.78 w=7 l=1
X254 a_n9311_n3159# a_n9311_n3159# a_n2148_3925# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.5
X255 a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# a_n9311_n3159# sky130_fd_pr__nfet_01v8 ad=2.34 pd=12.78 as=0 ps=0 w=6 l=2
C0 a_12876_1294# a_n7935_n484# 6.13428f
C1 a_n1455_n3628# a_n2686_12378# 6.63249f
C2 a_n2517_n3844# a_n1140_1442# 8.31e-20
C3 w_n8526_7510# a_n1140_1442# 0.073825f
C4 a_n7677_7899# a_n2686_12378# 8.79577f
C5 a_n2148_3925# a_n1140_1442# 7.84338f
C6 a_n1455_n3628# a_n2517_n3844# 2.20349f
C7 a_12876_1294# a_13154_n1884# 2.32624f
C8 a_n1455_n3628# a_n2148_3925# 3.69633f
C9 a_n2686_8022# a_n7935_n484# 80.9074f
C10 a_n7677_7899# a_n2517_n3844# 0.001258f
C11 a_n7677_7899# w_n8526_7510# 65.7903f
C12 a_n2148_3925# a_n7677_7899# 0.286692f
C13 a_12876_1294# w_n8526_7510# 7.233911f
C14 a_n2686_8022# a_n2686_12378# 11.3831f
C15 a_n2511_10156# a_n7935_n484# 0.001393f
C16 w_n8526_7510# a_n2686_8022# 37.1623f
C17 a_n8335_n2966# a_n7935_n484# 23.9697f
C18 a_n1455_n3628# a_n1140_1442# 3.70896f
C19 a_n7677_7899# a_n1140_1442# 4.35499f
C20 a_n2511_10156# a_n2686_12378# 17.2491f
C21 a_n2686_12378# a_n8335_n2966# 0.395315f
C22 a_n1455_n3628# a_n7677_7899# 6.68451f
C23 a_13154_n1884# a_n8335_n2966# 0.003517f
C24 a_n2511_10156# w_n8526_7510# 11.8465f
C25 w_n8526_7510# a_n8335_n2966# 0.004218f
C26 a_n2517_n3844# a_n8335_n2966# 0.008433f
C27 a_n2148_3925# a_n8335_n2966# 0.306594f
C28 a_n2686_12378# a_n7935_n484# 0.377983f
C29 a_13154_n1884# a_n7935_n484# 0.031857f
C30 a_n7677_7899# a_n2686_8022# 8.3313f
C31 w_n8526_7510# a_n7935_n484# 61.8363f
C32 a_n2148_3925# a_n7935_n484# 2.74686f
C33 a_n2517_n3844# a_n2686_12378# 3.07e-19
C34 w_n8526_7510# a_n2686_12378# 34.3645f
C35 a_n1140_1442# a_n8335_n2966# 0.266289f
C36 a_n2148_3925# a_n2686_12378# 3.61638f
C37 a_n2511_10156# a_n7677_7899# 1.33823f
C38 a_n1455_n3628# a_n8335_n2966# 0.002987f
C39 a_n7677_7899# a_n8335_n2966# 0.395315f
C40 a_n2148_3925# a_n2517_n3844# 8.31e-20
C41 a_n1140_1442# a_n7935_n484# 0.804612f
C42 a_12876_1294# a_n8335_n2966# 0.006808f
C43 a_n2511_10156# a_n2686_8022# 1.62135f
C44 a_n7677_7899# a_n7935_n484# 30.7558f
C45 a_n1140_1442# a_n2686_12378# 0.777962f
C46 a_n2517_n3844# a_n9311_n3159# 30.4089f
C47 a_13154_n1884# a_n9311_n3159# 30.131899f
C48 a_12876_1294# a_n9311_n3159# 13.8096f
C49 a_n1455_n3628# a_n9311_n3159# 16.057001f
C50 a_n8335_n2966# a_n9311_n3159# 0.109473p
C51 a_n1140_1442# a_n9311_n3159# 17.9088f
C52 a_n2148_3925# a_n9311_n3159# 15.1913f
C53 a_n2686_8022# a_n9311_n3159# 18.0352f
C54 a_n2511_10156# a_n9311_n3159# 0.597469f
C55 a_n2686_12378# a_n9311_n3159# 10.244599f
C56 a_n7935_n484# a_n9311_n3159# 72.983795f
C57 a_n7677_7899# a_n9311_n3159# 20.2068f
C58 w_n8526_7510# a_n9311_n3159# 0.351129p
.ends
