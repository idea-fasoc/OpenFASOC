* SPICE3 file created from opamp.ext - technology: sky130A

.subckt opamp minus plus vbias1 vbias2 output vdd gnd
X0 output vbias2 gnd gnd sky130_fd_pr__nfet_01v8 ad=4.752e+13p pd=3.0384e+08u as=7.038e+13p ps=4.1946e+08u w=6e+06u l=2e+06u M=48
X1 a_n1959_6502# a_n2329_8404# a_n6654_6298# vdd sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=6e+06u l=1e+06u M=12
X2 output a_n6654_6298# vdd vdd sky130_fd_pr__pfet_01v8 ad=6.93e+13p pd=4.398e+08u as=1.0404e+14p ps=6.3048e+08u w=7e+06u l=1e+06u M=60
X3 a_n1205_n495# a_n899_n3133# gnd gnd sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6e+06u l=2e+06u M=4
X4 a_n1205_n495# plus a_n2329_8404# gnd sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6e+06u l=1e+06u M=8
X5 a_n1959_6502# a_n2329_8404# vdd vdd sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=6e+06u l=1e+06u M=8
X6 a_n2329_8404# a_n2329_8404# a_n2407_8600# vdd sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=6e+06u l=1e+06u M=12
X7 output a_n1959_6502# sky130_fd_pr__cap_mim_m3_1 l=1.2e+07u w=1.2e+07u
X8 a_n2407_8600# a_n2329_8404# vdd vdd sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=6e+06u l=1e+06u M=8
X9 a_n1205_n495# minus a_n6654_6298# gnd sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6e+06u l=1e+06u M=8
X10 output a_n1959_6502# sky130_fd_pr__cap_mim_m3_1 l=1.2e+07u w=1.2e+07u
X11 output a_n1959_6502# sky130_fd_pr__cap_mim_m3_1 l=1.2e+07u w=1.2e+07u
X12 output a_n1959_6502# sky130_fd_pr__cap_mim_m3_1 l=1.2e+07u w=1.2e+07u
X13 output a_n1959_6502# sky130_fd_pr__cap_mim_m3_1 l=1.2e+07u w=1.2e+07u
X14 output a_n1959_6502# sky130_fd_pr__cap_mim_m3_1 l=1.2e+07u w=1.2e+07u
C0 output vdd 38.75fF
C1 output vbias2 17.81fF
C2 a_n1205_n495# a_n6654_6298# 5.60fF
C3 output plus 4.17fF
C4 minus plus 7.66fF
C5 a_n1205_n495# a_n2329_8404# 4.87fF
C6 a_n1959_6502# a_n6654_6298# 5.50fF
C7 a_n2407_8600# vdd 6.86fF
C8 a_n1959_6502# vdd 7.49fF
C9 vdd a_n6654_6298# 32.61fF
C10 a_n2407_8600# a_n2329_8404# 9.34fF
C11 a_n1959_6502# a_n2329_8404# 6.18fF
C12 a_n2329_8404# a_n6654_6298# 5.79fF
C13 output a_n1959_6502# 82.18fF
C14 output a_n6654_6298# 9.49fF
C15 minus a_n6654_6298# 3.95fF
C16 vdd a_n2329_8404# 18.76fF
C17 vbias2 gnd 64.53fF
C18 plus gnd 7.74fF
C19 minus gnd 8.61fF
C20 output gnd 63.97fF
C21 vdd gnd 303.27fF

.ends
