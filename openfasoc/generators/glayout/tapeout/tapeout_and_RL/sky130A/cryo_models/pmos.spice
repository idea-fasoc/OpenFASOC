*
* 4k spice models for p-channel thin oxide mosfets (low VTH).
*
*
* this scaled model was extracted by coolcad electroncis llc,
* akin akturk, akin.akturk@coolcadelectronics.com
*
* measurements used in model extraction correspond to the
* following W (um)/L (um) devices:
*'plowvt; w=3.0; l=1.0; m=1';
*'plowvt; w=7.0; l=8.0; m=1';
*'plowvt; w=7.0; l=0.35; m=1';
*'plowvt; w=0.42; l=8.0; m=1';
*'plowvt; w=0.42; l=0.35; m=1';
*
* to use the models, please set the circuit temperature
* to -269 in celcius. for standard spice, this can be done
* by adding the following line to netlist: .options temp=-269
*
*
*
*
.MODEL pshort PMOS
+ LEVEL = 54
+ VERSION = 4.6.5
+ BINUNIT = 2
+ PARAMCHK = 1
+ MOBMOD = 1
+ MTRLMOD = 0
+ RDSMOD = 0
+ IGCMOD = 0
+ IGBMOD = 0
+ CVCHARGEMOD = 0
+ CAPMOD = 2
+ RGATEMOD = 0
+ RBODYMOD = 0
+ TRNQSMOD = 0
+ ACNQSMOD = 0
+ FNOIMOD = 1
+ TNOIMOD = 0
+ DIOMOD = 1
+ TEMPMOD = 0
+ PERMOD = 1
+ GEOMOD = 0
+ WPEMOD = 0
+ EPSROX = 3.9
+ TOXE = 4.0349E-009
+ EOT = 4.0349E-009
+ TOXP = 4.0349E-009
+ TOXM = 4.0349E-009
+ DTOX = 0
+ XJ = 1.5E-007
+ NDEP = 4.0E+017
+ NGATE = 1E+022
+ NSD = 1E+020
+ XT = 1.55E-007
+ RSH = 0
+ RSHG = 0.1
+ VTH0 = -1.17
+ LVTH0 = 0.13e-7
+ WVTH0 = -0.23e-7
+ PVTH0 = 20e-16
+ VDDEOT = -1.5
+ LEFFEOT = 1
+ WEFFEOT = 10
+ TEMPEOT = 300.1
+ PHIN = 0
+ EASUB = 4.05
+ EPSRSUB = 11.7
+ NI0SUB = 1.45E+010
+ BG0SUB = 1.16
+ TBGASUB = 0.000702
+ TBGBSUB = 1108
+ ADOS = 1
+ BDOS = 1
+ VFB = -1
+ K1 = 0.618
+ K2 = 0.039145
+ K3 = -14.37
+ K3B = -4.92
+ WK1 = -4E-8
+ LK1 = -4E-8
+ PK1 = 8E-15
+ W0 = 4.104E-007
+ LPE0 = 7.535E-016
+ LPEB = 2.387E-011
+ VBM = -0.5
+ DVT0 = 0.007
+ DVT1 = 0.01
+ DVT2 = -0.05872
+ DVTP0 = 0
+ DVTP1 = 0.001
+ DVT0W = -100
+ DVT1W = 5.3E+006
+ DVT2W = -0.032
+ U0 = 0.17
+ LU0 = -6E-9
+ PU0 = 0E-17
+ WU0 = 0E-9
+ UA = -3.272E-010
+ UB = 2.2E-018
+ WUB = -3E-026
+ UC = 0.1
+ UD = 1.762E+017
+ UCS = 1
+ UP = -0.004472
+ LP = 1E-008
+ EU = 1.67
+ VSAT = 25E+004
+ WVSAT = 3.0
+ LVSAT = -10E-12
+ PVSAT = 1E-2
+ A0 = 0.5
+ AGS = 0.5529
+ B0 = 0
+ B1 = 0
+ KETA = -0.06744
+ A1 = 0.07557
+ A2 = 0.376
+ WINT = 7E-008
+ LINT = 1.5E-008
+ DWG = -1E-008
+ DWB = -1E-008
+ VOFF = -0.09
+ VOFFL = -0.4E-7
+ MINV = -9
+ WMINV = 0.39e-6
+ LMINV = 0.0e-6
+ PMINV = -0.7e-13
+ NFACTOR = 4
+ ETA0 = 12E-005
+ ETAB = 0.687
+ DSUB = 0.9
+ CIT = 0
+ CDSC = 4.441E-016
+ CDSCB = -0.001393
+ CDSCD = 0
+ PCLM = 0.839
+ LPCLM = 6E-7
+ PDIBLC1 = 2
+ PDIBLC2 = 0.001192
+ PDIBLCB = 0
+ DROUT = 0.4
+ PSCBE1 = 9.24E+008
+ PSCBE2 = 0.001
+ PVAG = 1
+ DELTA = 0.07
+ PDELTA = -5E-15
+ FPROUT = 0
+ PDITS = 0.1
+ PDITSL = 6.754E+006
+ PDITSD = 1
+ LAMBDA = 0
+ VTL = 3.7E+004
+ WVTL = 1E-2
+ LC = 0.2
+ XN = 10
+ PHIG = 4.05
+ EPSRGATE = 11.7
+ RDSW = 3000
+ LRDSW = 4e-5
+ WRDSW = 0e-5
+ RDSWMIN = 00
+ RDW = 100
+ RDWMIN = 0
+ RSW = 100
+ RSWMIN = 0
+ PRWG = 8.421E-005
+ PRWB = -0.814
+ WR = 1.21
+ ALPHA0 = 1E-005
+ ALPHA1 = 0
+ BETA0 = 15
+ AGIDL = 1E-015
+ BGIDL = 2.3E+009
+ CGIDL = 0.5
+ EGIDL = 0.8
+ AGISL = 0
+ BGISL = 2.3E+009
+ CGISL = 0.5
+ EGISL = 0.8
+ AIGBACC = 0.43
+ BIGBACC = 0.054
+ CIGBACC = 0.075
+ NIGBACC = 1
+ AIGBINV = 0.35
+ BIGBINV = 0.03
+ CIGBINV = 0.006
+ EIGBINV = 1.1
+ NIGBINV = 3
+ AIGC = 0.54
+ BIGC = 0.054
+ CIGC = 0.075
+ AIGSD = 0.43
+ BIGSD = 0.054
+ CIGSD = 0.075
+ DLCIG = 1.124E-008
+ AIGS = 0.0136
+ BIGS = 0.00171
+ CIGS = 0.075
+ AIGD = 0.0136
+ BIGD = 0.00171
+ CIGD = 0.075
+ DLCIGD = 0
+ NIGC = 1
+ POXEDGE = 1
+ PIGCD = 1
+ NTOX = 1
+ TOXREF = 4.0349E-009
+ VFBSDOFF = 0
+ XPART = 0
+ CGSO = 3.161E-011
+ CGDO = 3.161E-011
+ CGBO = 0
+ CGSL = 1.121E-010
+ CGDL = 1.121E-010
+ CKAPPAS = 0.6
+ CKAPPAD = 0.6
+ CF = 2.854E-010
+ CLC = 1E-007
+ CLE = 0.6
+ DLC = 1.124E-008
+ DWC = 0
+ VFBCV = -1
+ NOFF = 2
+ VOFFCV = -0.2538
+ VOFFCVL = 0
+ MINVCV = 0
+ ACDE = 1
+ MOIN = 15
+ XRCRG1 = 12
+ XRCRG2 = 1
+ RBPB = 50
+ RBPD = 50
+ RBPS = 15
+ RBDB = 50
+ RBSB = 50
+ GBMIN = 1E-012
+ RBPS0 = 50
+ RBPSL = 0
+ RBPSW = 0
+ RBPSNF = 0
+ RBPD0 = 50
+ RBPDL = 0
+ RBPDW = 0
+ RBPDNF = 0
+ RBPBX0 = 100
+ RBPBXL = 0
+ RBPBXW = 0
+ RBPBXNF = 0
+ RBPBY0 = 100
+ RBPBYL = 0
+ RBPBYW = 0
+ RBPBYNF = 0
+ RBSBX0 = 100
+ RBSBY0 = 100
+ RBDBX0 = 100
+ RBDBY0 = 100
+ RBSDBXL = 0
+ RBSDBXW = 0
+ RBSDBXNF = 0
+ RBSDBYL = 0
+ RBSDBYW = 0
+ RBSDBYNF = 0
+ NOIA = 6.25E+041
+ NOIB = 3.125E+026
+ NOIC = 8.75
+ EM = 4.1E+007
+ AF = 1
+ EF = 1
+ KF = 0
+ LINTNOI = 0
+ NTNOI = 1
+ TNOIA = 1.5
+ TNOIB = 3.5
+ RNOIA = 0.577
+ RNOIB = 0.5164
+ DMCG = 0
+ DMCI = 0
+ DMDG = 0
+ DMCGT = 0
+ DWJ = 0
+ XGW = 0
+ XGL = 0
+ XL = 0
+ XW = 0
+ NGCON = 1
+ IJTHSREV = 0.1
+ IJTHSFWD = 0.1
+ XJBVS = 1
+ BVS = 10
+ JSS = 0.0001
+ JSWS = 0
+ JSWGS = 0
+ JTSS = 0
+ JTSSWS = 0
+ JTSSWGS = 0
+ JTWEFF = 0
+ NJS = 15
+ NJTS = 20
+ NJTSSW = 20
+ NJTSSWG = 20
+ XTSS = 0.02
+ XTSSWS = 0.02
+ XTSSWGS = 0.02
+ VTSS = 10
+ VTSSWS = 10
+ VTSSWGS = 10
+ TNJTS = 0
+ TNJTSSW = 0
+ TNJTSSWG = 0
+ CJS = 0.0005
+ MJS = 0.5
+ MJSWS = 0.33
+ CJSWS = 5E-010
+ CJSWGS = 5E-010
+ MJSWGS = 0.33
+ PBS = 1
+ PBSWS = 1
+ PBSWGS = 1
+ IJTHDREV = 4.878E-003
+ IJTHDFWD = 4.878E-003
+ XJBVD = 1
+ BVD = 10
+ JSD = 1.004E-014
+ JSWD = 2.467E-018
+ JSWGD = 0
+ JTSD = 0
+ JTSSWD = 0
+ JTSSWGD = 0
+ NJD = 15
+ NJTSD = 20
+ NJTSSWD = 20
+ NJTSSWGD = 20
+ XTSD = 0.02
+ XTSSWD = 0.02
+ XTSSWGD = 0.02
+ VTSD = 10
+ VTSSWD = 10
+ VTSSWGD = 10
+ TNJTSD = 0
+ TNJTSSWD = 0
+ TNJTSSWGD = 0
+ CJD = 0.0009368
+ MJD = 0.3545
+ MJSWD = 0.3141
+ CJSWD = 7.65E-011
+ CJSWGD = 5E-010
+ MJSWGD = 0.33
+ PBD = 0.9594
+ PBSWD = 0.9109
+ PBSWGD = 1
+ TNOM = -253
+ UTE = 0
+ UCSTE = -0.004775
+ KT1 = -0.11
+ KT1L = 0
+ KT2 = 0.022
+ UA1 = 1E-009
+ UB1 = -1E-018
+ UC1 = -0.056
+ UD1 = 0
+ AT = 3.3E+004
+ PRT = 0
+ XTIS = 3
+ XTID = 3
+ TPB = 0
+ TPBSW = 0
+ TPBSWG = 0
+ TCJ = 0
+ TCJSW = 0
+ TCJSWG = 0
+ TVOFF = 0
+ TVFBSDOFF = 0
+ SAREF = 0
+ SBREF = 0
+ WLOD = 2E-006
+ KU0 = 4E-006
+ KVSAT = 0.2
+ TKU0 = 0
+ LKU0 = 1E-006
+ WKU0 = 1E-006
+ PKU0 = 0
+ LLODKU0 = 1.1
+ WLODKU0 = 1.1
+ KVTH0 = -2E-008
+ LKVTH0 = 1.1E-006
+ WKVTH0 = 1.1E-006
+ PKVTH0 = 0
+ LLODVTH = 1
+ WLODVTH = 1
+ STK2 = 0
+ LODK2 = 1
+ STETA0 = 0
+ LODETA0 = 1
+ WEB = 0
+ WEC = 0
+ KVTH0WE = 0
+ K2WE = 0
+ KU0WE = 0
+ SCREF = 1E-006
+ WL = 7.641E-015
+ WLN = 0.9975
+ WW = -1E-014
+ WWN = 1.012
+ WWL = -1.218E-021
+ LL = -3.165E-015
+ LLN = 1
+ LW = -4.827E-015
+ LWN = 1
+ LWL = 1.182E-021
+ LLC = 0
+ LWC = 0
+ LWLC = 0
+ WLC = 0
+ WWC = 0
+ WWLC = 0
*
*
