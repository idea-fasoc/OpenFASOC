v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -40 0 -0 -0 {}
N 60 0 90 0 {}
C {sky130_fd_pr/ind_generic.sym} 30 0 3 0 {name=L1
**N=1
**L=1
** Other Params
spiceprefix=X
model=ind_05_220
}
C {devices/iopin.sym} 80 0 0 0 {name=p1 lab=xxx}
C {devices/iopin.sym} -30 0 2 0 {name=p2 lab=xxx}
